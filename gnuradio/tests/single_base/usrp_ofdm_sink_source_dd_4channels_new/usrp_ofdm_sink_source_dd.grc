options:
  parameters:
    category: Custom
    description: USRP Sink/Source Style1 OFDM radar zero-Doppler range profile. Scheduled Unified OfdmBurstRx (Torch CUDA DSP).
    generate_options: qt_gui
    id: usrp_ofdm_sink_source_dd
    output_language: python
  states: {}

blocks:
- name: RX_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: R_max
  id: variable
  parameters:
    comment: 最大不模糊距离 (m)，R = c/(2·BW)·N_fft
    value: 3e8/2/samp_rate*fft_len
  states: {}
- name: TX_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: burst_len_samples
  id: variable
  parameters:
    comment: CPI time-domain samples; num_symbols * (fft_len + cp_len)
    value: num_symbols * (fft_len + cp_len)
  states: {}
- name: cp_len
  id: variable
  parameters:
    comment: Cyclic prefix length (samples); ~78 m round-trip @ 245.76 MHz
    value: '128'
  states: {}
- name: factor
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.008'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: 载频 (Hz)；须与 v_max 公式一致，否则速度估计会偏
    value: 6.0e9
  states: {}
- name: idle_ms
  id: variable
  parameters:
    comment: TX burst idle gap (ms); aids RX re-sync between CPIs
    value: '20'
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: min_out_buf_val
  id: variable
  parameters:
    value: packet_len*2
  states: {}
- name: music_enable
  id: variable_qtgui_check_box
  parameters:
    comment: Enable 1D range MUSIC super-resolution on CPI complex range profile (dev0+dev1)
    'false': 'False'
    gui_hint: 0,0,1,1
    label: MUSIC Enable
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: n_carriers
  id: variable
  parameters:
    value: fft_len - 2
  states: {}
- name: num_delay_samp
  id: variable_qtgui_range
  parameters:
    comment: Recalibrate after fft_len/rate change; align loopback peak to 0 m
    label: Number of delayed samples
    start: '0'
    step: '1'
    stop: packet_len
    value: '277'
  states: {}
- name: num_symbols
  id: variable
  parameters:
    comment: CPI OFDM symbols per burst; 4 avoids qpsk>8192 sched limit at fft_len=2048
    value: '4'
  states: {}
- name: packet_len
  id: variable
  parameters:
    comment: QPSK bytes per burst; derived from CPI symbol count
    value: num_symbols * n_carriers // 4
  states: {}
- name: range_bin_step
  id: variable
  parameters:
    comment: 距离谱横轴步进 (m/bin)；GRC 显示 305.176m = 0.305 m
    value: 3e8/(2*int(fft_len*subcarrier_spacing)*zeropadding_fac)
  states: {}
- name: range_roi
  id: variable
  parameters:
    value: (0.0, 3.5)
  states: {}
- name: record_enable
  id: variable_qtgui_check_box
  parameters:
    comment: Record CPI multi-ch complex range profiles to record_file_path
    'false': 'False'
    gui_hint: 0,1,1,1
    label: Record Enable
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: Filled per-session by install_usrp_ofdm_4ch_record_flow
    value: '"/dev/null"'
  states: {}
- name: record_max_frames
  id: variable
  parameters:
    comment: Fixed CPI frames per Record Enable session
    value: '55'
  states: {}
- name: record_output_dir
  id: variable
  parameters:
    comment: Session dir under data/experiment (divide_profiles_NNN + CSV)
    value: repo_data_dir("data", "experiment", "usrp_ofdm_sink_source_dd")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(fft_len * subcarrier_spacing)
  states: {}
- name: subcarrier_spacing
  id: variable
  parameters:
    value: 120e3
  states: {}
- name: target_pos_x_cm
  id: variable_qtgui_range
  parameters:
    label: Target X (cm)
    start: '-100'
    step: '10'
    stop: '100'
    value: '0'
  states: {}
- name: target_pos_y_cm
  id: variable_qtgui_range
  parameters:
    label: Target Y (cm)
    start: '-100'
    step: '10'
    stop: '100'
    value: '0'
  states: {}
- name: time_lead_s
  id: variable
  parameters:
    comment: Style1 tx_time lead (s); maps from wait_to_start
    value: wait_to_start
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: zeropadding_fac
  id: variable
  parameters:
    value: '4'
  states: {}
- name: address
  id: parameter
  parameters:
    comment: USRP 349B642; QSFP 10.2; external 10MHz+PPS
    label: address (349B642)
    type: str
    value: '"type=x4xx,serial=349B642,mgmt_addr=192.168.1.100,addr=192.168.10.2,clock_source=internal,time_source=internal"'
  states: {}
- name: import_record_paths_0
  id: import
  parameters:
    comment: repo_data_dir for record_output_dir
    imports: from isac_imp.record_paths import repo_data_dir
  states: {}
- name: install_usrp_ofdm_4ch_record_flow_snippet
  id: snippet
  parameters:
    code: |
      from isac_imp.mics_test_record_flow import install_usrp_ofdm_4ch_record_flow
      install_usrp_ofdm_4ch_record_flow(self)
    comment: Session allocate + CSV metadata + auto-stop
    priority: '1'
    section: main_after_init
  states: {}
- name: ofdm_burst_rx_0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp import ofdm_burst_rx as _obr


      class OfdmBurstRx4Block(_obr.OfdmBurstRxBlock):
          """GRC epy 探测用：强制 4 输入。父类勿直接 import，否则 extract 会误选 1 口。"""

          def __init__(
              self,
              fft_len=2048,
              cp_len=512,
              num_symbols=4,
              zeropadding_fac=4,
              num_delay_samp=0,
              device="cuda",
              length_tag_key="packet_len",
              log_interval_s=1.0,
              range_roi=(0.0, 30.0),
              range_bin_step=0.305,
              music_enable=True,
              num_sources=1,
              subarray_size=16,
              threshold=0.1,
              plot_title="Range Profile",
              num_channels=4,
              plot_title_prefix="Range Profile",
              record_enable=False,
              record_file_path="",
              record_max_frames=55,
          ):
              super().__init__(
                  fft_len=fft_len,
                  cp_len=cp_len,
                  num_symbols=num_symbols,
                  zeropadding_fac=zeropadding_fac,
                  num_delay_samp=num_delay_samp,
                  device=device,
                  length_tag_key=length_tag_key,
                  log_interval_s=log_interval_s,
                  range_roi=range_roi,
                  range_bin_step=range_bin_step,
                  music_enable=music_enable,
                  num_sources=num_sources,
                  subarray_size=subarray_size,
                  threshold=threshold,
                  plot_title=plot_title,
                  num_channels=4,
                  plot_title_prefix=plot_title_prefix,
                  record_enable=record_enable,
                  record_file_path=record_file_path,
                  record_max_frames=record_max_frames,
              )


      blk = OfdmBurstRx4Block
    comment: 'Unified 4-ch RX: batch Torch CUDA DSP + per-ch plot/MUSIC'
    cp_len: cp_len
    device: '''cuda'''
    fft_len: fft_len
    length_tag_key: length_tag_key
    log_interval_s: '5.0'
    music_enable: music_enable
    num_channels: '4'
    num_delay_samp: num_delay_samp
    num_sources: '1'
    num_symbols: num_symbols
    plot_title: '"Range Profile ch0"'
    plot_title_prefix: '"Range Profile"'
    range_bin_step: range_bin_step
    range_roi: range_roi
    record_enable: record_enable
    record_file_path: record_file_path
    record_max_frames: record_max_frames
    subarray_size: '16'
    threshold: '0.1'
    zeropadding_fac: zeropadding_fac
  states: {}
- name: ofdm_burst_tx_source_0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.ofdm_burst_tx_source import OfdmBurstTxSourceBlock

      blk = OfdmBurstTxSourceBlock
    comment: 'Unified TX: ResourceGrid + IFFT/CP + factor + Style1/sched'
    cp_len: cp_len
    device: '''cuda'''
    factor: factor
    fft_len: fft_len
    idle_ms: idle_ms
    length_tag_key: length_tag_key
    num_bits_per_symbol: '2'
    num_delay_samp: num_delay_samp
    num_symbols: num_symbols
    samp_rate: float(samp_rate)
    scheduled_rx: 'True'
    seed: '42'
    subcarrier_spacing: subcarrier_spacing
    time_lead_s: time_lead_s
  states: {}
- name: patch_usrp_source_factory_snippet
  id: snippet
  parameters:
    code: |
      from isac_imp.scheduled_usrp_source import patch_usrp_source_factory
      patch_usrp_source_factory()
    comment: Force uhd.usrp_source(..., False) before block construction
    section: init_before_blocks
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: fft_len + cp_len
    srate: samp_rate
    type: complex
    update_time: '0.50'
  states: {}
- name: scheduled_rx_bind_snippet
  id: snippet
  parameters:
    code: |
      import time
      from gnuradio import uhd
      now = time.time()
      self.uhd_usrp_sink_0.set_time_now(uhd.time_spec(now), uhd.ALL_MBOARDS)
      self.uhd_usrp_source_0.set_time_now(uhd.time_spec(now), uhd.ALL_MBOARDS)
      _maxn = max(16384, int(self.burst_len_samples))
      self.uhd_usrp_source_0.set_max_noutput_items(_maxn)
      self.uhd_usrp_source_0.set_min_output_buffer(max(int(self.min_out_buf_val), 2 * int(self.burst_len_samples)))
      self.ofdm_burst_tx_source_0.set_min_output_buffer(0, max(2 * int(self.burst_len_samples), int(self.min_out_buf_val)))
      self.ofdm_burst_tx_source_0.bind_scheduled_rx(self.uhd_usrp_source_0)
    comment: Bind USRP Source for scheduled NUM_SAMPS_AND_DONE RX
    section: main_after_init
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    center_freq0: freq
    center_freq1: freq
    center_freq2: freq
    center_freq3: freq
    clock_rate: '0'
    clock_source0: internal
    dev_addr: address
    dev_args: '""'
    gain0: TX_gain
    gain1: TX_gain
    gain2: TX_gain
    gain3: TX_gain
    len_tag_name: ''
    nchan: '4'
    samp_rate: samp_rate
    stream_args: num_send_frames=512,send_buff_size=25000000
    stream_chans: '[0, 1, 2, 3]'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    ant1: '"RX1"'
    ant2: '"RX1"'
    ant3: '"RX1"'
    center_freq0: freq
    center_freq1: freq
    center_freq2: freq
    center_freq3: freq
    clock_rate: '0'
    clock_source0: internal
    dev_addr: address
    dev_args: '""'
    gain0: RX_gain
    gain1: RX_gain
    gain2: RX_gain
    gain3: RX_gain
    minoutbuf: min_out_buf_val
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    stream_args: num_recv_frames=512,recv_buff_size=25000000
    stream_chans: '[0, 1, 2, 3]'
    sync: none
    type: fc32
  states: {}

connections:
- [ofdm_burst_tx_source_0, '0', qtgui_time_sink_x_0, '0']
- [ofdm_burst_tx_source_0, '0', uhd_usrp_sink_0, '0']
- [ofdm_burst_tx_source_0, '0', uhd_usrp_sink_0, '1']
- [ofdm_burst_tx_source_0, '0', uhd_usrp_sink_0, '2']
- [ofdm_burst_tx_source_0, '0', uhd_usrp_sink_0, '3']
- [ofdm_burst_tx_source_0, tx_freq_cpi, ofdm_burst_rx_0, tx_freq_cpi]
- [ofdm_burst_tx_source_0, tx_schedule, ofdm_burst_rx_0, tx_schedule]
- [uhd_usrp_source_0, '0', ofdm_burst_rx_0, '0']
- [uhd_usrp_source_0, '1', ofdm_burst_rx_0, '1']
- [uhd_usrp_source_0, '2', ofdm_burst_rx_0, '2']
- [uhd_usrp_source_0, '3', ofdm_burst_rx_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
