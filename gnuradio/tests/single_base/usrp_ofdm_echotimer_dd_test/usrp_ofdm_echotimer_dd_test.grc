options:
  parameters:
    category: Custom
    description: USRP OFDM radar 1D range profile (0~R_max) + DD spectrogram. RX packet_len tags via echotimer.
    generate_options: qt_gui
    id: usrp_ofdm_echotimer_dd
    output_language: python
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: subcarrier_spacing
  id: variable
  parameters:
    value: 60e3
  states: {}
- name: zeropadding_fac
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(fft_len * subcarrier_spacing)
  states: {}
- name: R_max
  id: variable
  parameters:
    comment: 最大不模糊距离 (m)，R = c/(2·BW)·N_fft
    value: 3e8/2/samp_rate*fft_len
  states: {}
- name: range_bin_step
  id: variable
  parameters:
    comment: 距离谱横轴步进 (m/bin)；GRC 显示 305.176m = 0.305 m
    value: 3e8/(2*int(fft_len*subcarrier_spacing)*zeropadding_fac)
  states: {}
- name: RX_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: TX_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: burst_len_samples
  id: variable
  parameters:
    comment: CPI time-domain samples; transpose_len * (fft_len + fft_len//4)
    value: transpose_len * (fft_len + fft_len//4)
  states: {}
- name: discarded_carriers
  id: variable
  parameters:
    value: '[]'
  states: {}
- name: factor
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.008'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: 载频 (Hz)；须与 v_max 公式一致，否则速度估计会偏
    value: 6.0e9
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: min_out_buf_val
  id: variable
  parameters:
    comment: 2x CPI time-domain length per gr-radar buffer guidance
    value: int(2*transpose_len*(fft_len+fft_len/4))
  states: {}
- name: n_carriers
  id: variable
  parameters:
    comment: occupied subcarriers (full band minus DC); matches gr_setup.resolve_gr_carrier_tuples
    value: fft_len - 2
  states: {}
- name: num_delay_samp
  id: variable_qtgui_range
  parameters:
    comment: Align to symbol_len=fft_len+fft_len//4 multiples; misaligned delay drops CPI symbols on RX
    label: Number of delayed samples
    start: '0'
    step: '1'
    stop: packet_len
    value: '161'
  states: {}
- name: packet_len
  id: variable
  parameters:
    comment: QPSK bytes per burst; derived from CPI symbol count
    value: transpose_len * n_carriers // 4
  states: {}
- name: transpose_len
  id: variable
  parameters:
    comment: CPI OFDM symbols per burst; 4 avoids qpsk>8192 sched limit at fft_len=2048
    value: '4'
  states: {}
- name: v_max
  id: variable
  parameters:
    comment: 最大不模糊速度 (m/s)，v = c/(4·fc·T_sym)
    value: 3e8/(4*freq*(fft_len+fft_len/4)/samp_rate)
  states: {}
- name: value_range
  id: variable
  parameters:
    comment: Spectrogram x-axis display label (USRP mode)
    value: '"Range (m)"'
  states: {}
- name: velocity_bin_step
  id: variable
  parameters:
    comment: 多普勒谱横轴步进 (m/s/bin)，4 点对称 FFT
    value: 2*v_max/transpose_len
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: address
  id: parameter
  parameters:
    comment: USRP 349B642; QSFP 10.2; external 10MHz+PPS
    label: address (349B642)
    type: str
    value: '"type=x4xx,serial=349B642,mgmt_addr=192.168.1.100,addr=192.168.10.2,clock_source=external,time_source=external"'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    minoutbuf: 2*fft_len*zeropadding_fac
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    comment: Non-coherent sum over CPI symbols (decim=transpose_len)
    decim: transpose_len
    type: float
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: factor
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: fft_len*zeropadding_fac
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    tagname: length_tag_key
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    minoutbuf: 2*transpose_len
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    minoutbuf: 2*transpose_len
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_len*zeropadding_fac
    forward: 'True'
    minoutbuf: 2*fft_len*zeropadding_fac
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_len*zeropadding_fac)
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    fft_size: transpose_len
    forward: 'False'
    minoutbuf: 2*fft_len*zeropadding_fac
    shift: 'False'
    type: complex
    window: window.blackmanharris(transpose_len)
  states: {}
- name: ofdm_cpi_tag_normalizer_rx_0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.ofdm_cpi_tag_normalizer import OfdmCpiTagNormalizerBlock

      blk = OfdmCpiTagNormalizerBlock
    comment: Retag RX FFT for GR divide (packet_len=transpose_len symbols)
    fft_len: fft_len
    length_tag_key: length_tag_key
    minoutbuf: 2*transpose_len
    transpose_len: transpose_len
  states: {}
- name: ofdm_cpi_tag_normalizer_tx_0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.ofdm_cpi_tag_normalizer import OfdmCpiTagNormalizerBlock

      blk = OfdmCpiTagNormalizerBlock
    comment: Retag Sionna TX ref for GR divide (packet_len=transpose_len symbols)
    fft_len: fft_len
    length_tag_key: length_tag_key
    minoutbuf: 2*transpose_len
    transpose_len: transpose_len
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft_len
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: fft_len + fft_len//4
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    comment: Zero-Doppler range profile, 0~R_max m (full spectrum)
    grid: 'True'
    label1: Range Profile
    name: '"Range Profile"'
    vlen: fft_len*zeropadding_fac
    x_axis_label: '"Range"'
    x_start: '0'
    x_step: range_bin_step
    x_units: '"m"'
    y_axis_label: '"Power (dB)"'
    y_units: '"dB"'
    ymax: '0'
    ymin: '-40'
  states: {}
- name: radar_ofdm_cyclic_prefix_remover_cvc_0
  id: radar_ofdm_cyclic_prefix_remover_cvc
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
  states: {}
- name: radar_ofdm_divide_vcvc_0
  id: radar_ofdm_divide_vcvc
  parameters:
    discarded_carriers: discarded_carriers
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
    num_sync_words: '0'
    vlen_in: fft_len
    vlen_out: (fft_len-len(discarded_carriers))*zeropadding_fac
  states: {}
- name: radar_qtgui_spectrogram_plot_0
  id: radar_qtgui_spectrogram_plot
  parameters:
    autoscale_z: 'True'
    axis_x: '[0,R_max]'
    axis_y: '[0,v_max]'
    axis_z: '[-15,-12]'
    interval: '500'
    label: '''OFDM Radar DD'''
    len_key: '"packet_len"'
    vlen: fft_len*zeropadding_fac
    xlabel: value_range
    ylabel: '''Velocity (m/s)'''
  states: {}
- name: radar_transpose_matrix_vcvc_0
  id: radar_transpose_matrix_vcvc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: 2*fft_len*zeropadding_fac
    vlen_in: fft_len*zeropadding_fac
    vlen_out: transpose_len
  states: {}
- name: radar_transpose_matrix_vcvc_0_0
  id: radar_transpose_matrix_vcvc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: 2*fft_len*zeropadding_fac
    vlen_in: transpose_len
    vlen_out: fft_len*zeropadding_fac
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    antenna_rx: '''RX1'''
    antenna_tx: '''TX/RX'''
    args_rx: address
    args_tx: address
    center_freq: freq
    channel_rx: '0'
    channel_tx: '0'
    clock_source_rx: '''external'''
    clock_source_tx: '''external'''
    comment: external 10MHz REF IN + PPS IN; must match device args
    gain_rx: RX_gain
    gain_tx: TX_gain
    minoutbuf: min_out_buf_val
    num_delay_samps: int(num_delay_samp)
    samp_rate: int(samp_rate)
    time_source_rx: '''external'''
    time_source_tx: '''external'''
    timeout_rx: '0.2'
    timeout_tx: '0.2'
    wait_rx: wait_to_start
    wait_tx: wait_to_start
  states: {}
- name: sionna_resource_grid_tx_0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.sionna_resource_grid_tx import SionnaResourceGridTxBlock

      blk = SionnaResourceGridTxBlock
    comment: Sionna ResourceGridMapper; replaces carrier_allocator
    cp_len: fft_len//4
    device: '''cpu'''
    fft_len: fft_len
    length_tag_key: length_tag_key
    minoutbuf: 4*transpose_len
    num_bits_per_symbol: '2'
    seed: '42'
    subcarrier_spacing: subcarrier_spacing
    transpose_len: transpose_len
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', radar_usrp_echotimer_cc_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0_0, '0', radar_qtgui_spectrogram_plot_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_vxx_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', ofdm_cpi_tag_normalizer_rx_0, '0']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_1, '0', radar_transpose_matrix_vcvc_0, '0']
- [fft_vxx_0_1_0, '0', radar_transpose_matrix_vcvc_0_0, '0']
- [ofdm_cpi_tag_normalizer_rx_0, '0', radar_ofdm_divide_vcvc_0, '1']
- [ofdm_cpi_tag_normalizer_tx_0, '0', radar_ofdm_divide_vcvc_0, '0']
- [radar_ofdm_cyclic_prefix_remover_cvc_0, '0', fft_vxx_0_0, '0']
- [radar_ofdm_divide_vcvc_0, '0', fft_vxx_0_1, '0']
- [radar_transpose_matrix_vcvc_0, '0', fft_vxx_0_1_0, '0']
- [radar_transpose_matrix_vcvc_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [radar_usrp_echotimer_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [radar_usrp_echotimer_cc_0, '0', radar_ofdm_cyclic_prefix_remover_cvc_0, '0']
- [sionna_resource_grid_tx_0, '0', fft_vxx_0, '0']
- [sionna_resource_grid_tx_0, '0', ofdm_cpi_tag_normalizer_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
