options:
  parameters:
    category: Custom
    description: USRP Sink/Source Style1 OFDM radar zero-Doppler range profile. Scheduled RX (NUM_SAMPS_AND_DONE per CPI); packet_len via packet_len_tagger.
    generate_options: qt_gui
    id: usrp_ofdm_sink_source_dd
    output_language: python
  states: {}

blocks:
- name: RX_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: R_max
  id: variable
  parameters:
    comment: 最大不模糊距离 (m)，R = c/(2·BW)·N_fft
    value: 3e8/2/samp_rate*fft_len
  states: {}
- name: TX_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: burst_len_samples
  id: variable
  parameters:
    comment: CPI time-domain samples; transpose_len * (fft_len + fft_len//4)
    value: transpose_len * (fft_len + fft_len//4)
  states: {}
- name: factor
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1.204e-5'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: 载频 (Hz)；须与 v_max 公式一致，否则速度估计会偏
    value: 6.0e9
  states: {}
- name: idle_ms
  id: variable
  parameters:
    comment: TX burst idle gap (ms); aids RX re-sync between CPIs
    value: '10'
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: min_out_buf_val
  id: variable
  parameters:
    value: packet_len*2
  states: {}
- name: music_enable
  id: variable_qtgui_check_box
  parameters:
    comment: Enable 1D range MUSIC super-resolution on CPI complex range profile (dev0+dev1)
    'false': 'False'
    gui_hint: 0,4,1,1
    label: MUSIC Enable
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: n_carriers
  id: variable
  parameters:
    value: fft_len - 2
  states: {}
- name: num_delay_samp
  id: variable_qtgui_range
  parameters:
    comment: Recalibrate after fft_len/rate change; align loopback peak to 0 m
    label: Number of delayed samples
    start: '0'
    step: '1'
    stop: packet_len
    value: '161'
  states: {}
- name: packet_len
  id: variable
  parameters:
    comment: QPSK bytes per burst; derived from CPI symbol count
    value: transpose_len * n_carriers // 4
  states: {}
- name: range_bin_step
  id: variable
  parameters:
    comment: 距离谱横轴步进 (m/bin)；GRC 显示 305.176m = 0.305 m
    value: 3e8/(2*int(fft_len*subcarrier_spacing)*zeropadding_fac)
  states: {}
- name: range_roi
  id: variable
  parameters:
    value: (0.0, 3.5)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(fft_len * subcarrier_spacing)
  states: {}
- name: subcarrier_spacing
  id: variable
  parameters:
    value: 60e3
  states: {}
- name: time_lead_s
  id: variable
  parameters:
    comment: Style1 tx_time lead (s); maps from wait_to_start
    value: wait_to_start
  states: {}
- name: transpose_len
  id: variable
  parameters:
    comment: CPI OFDM symbols per burst; 4 avoids qpsk>8192 sched limit at fft_len=2048
    value: '4'
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: zeropadding_fac
  id: variable
  parameters:
    value: '4'
  states: {}
- name: address
  id: parameter
  parameters:
    comment: USRP 349B642; QSFP 10.2; external 10MHz+PPS
    label: address (349B642)
    type: str
    value: '"type=x4xx,serial=349B642,mgmt_addr=192.168.1.100,addr=192.168.10.2,clock_source=internal,time_source=internal"'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: factor
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    type: complex
  states: {}
- name: burst_iq_tag_tx_0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.burst_iq_tag_tx import BurstIqTagTxBlock

      blk = BurstIqTagTxBlock
    burst_len_samples: burst_len_samples
    comment: Style1 TX + scheduled UHD recv per CPI
    idle_ms: idle_ms
    length_tag_key: length_tag_key
    minoutbuf: min_out_buf_val
    num_delay_samp: num_delay_samp
    samp_rate: float(samp_rate)
    scheduled_rx: 'True'
    time_lead_s: time_lead_s
  states: {}
- name: cpi_rate_probe_0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.cpi_rate_probe import CpiRateProbeBlock

      blk = CpiRateProbeBlock
    comment: CPI/s diagnostic
    label: '''scheduled_rx'''
    length_tag_key: length_tag_key
    log_interval_s: '1.0'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    tagname: length_tag_key
  states: {state: disabled}
- name: echotimer_rx_compensator_0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.echotimer_rx_compensator import EchotimerRxCompensatorBlock

      blk = EchotimerRxCompensatorBlock
    burst_len_samples: burst_len_samples
    comment: Echotimer num_delay_samps shift + rx_time (ref gr-radar)
    length_tag_key: length_tag_key
    num_delay_samps: num_delay_samp
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    minoutbuf: 2*transpose_len
    shift: 'True'
    type: complex
    window: ()
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    minoutbuf: 2*transpose_len
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: ofdm_cpi_tag_normalizer_rx_0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.ofdm_cpi_tag_normalizer import OfdmCpiTagNormalizerBlock

      blk = OfdmCpiTagNormalizerBlock
    comment: RX FFT 符号流 CPI tag 归一化
    fft_len: fft_len
    length_tag_key: length_tag_key
    minoutbuf: (2*transpose_len)
    transpose_len: transpose_len
  states: {}
- name: ofdm_range_profile_0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.ofdm_range_profile import OfdmRangeProfileBlock

      blk = OfdmRangeProfileBlock
    fft_len: fft_len
    transpose_len: transpose_len
    zeropadding_fac: zeropadding_fac
  states: {}
- name: packet_len_tagger_0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.packet_len_tagger import PacketLenTaggerBlock

      blk = PacketLenTaggerBlock
    burst_len_samples: burst_len_samples
    comment: packet_len tags on scheduled RX bursts
    length_tag_key: length_tag_key
    use_rx_time: 'True'
  states: {}
- name: patch_usrp_source_factory_snippet
  id: snippet
  parameters:
    code: |
      from isac_imp.scheduled_usrp_source import patch_usrp_source_factory
      patch_usrp_source_factory()
    comment: Force uhd.usrp_source(..., False) before block construction
    section: init_before_blocks
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft_len
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: fft_len + fft_len//4
    srate: samp_rate
    type: complex
  states: {}
- name: radar_ofdm_cyclic_prefix_remover_cvc_0
  id: radar_ofdm_cyclic_prefix_remover_cvc
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
  states: {}
- name: range_music_block_dev1
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.range_music_block import RangeMusicBlock

      blk = RangeMusicBlock
    music_enable: music_enable
    num_sources: '1'
    range_bin_step: range_bin_step
    range_roi: range_roi
    subarray_size: '16'
    threshold: '0.1'
    vlen_in: fft_len*zeropadding_fac
  states: {}
- name: range_profile_plot_dev1
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.range_profile_plot import RangeProfilePlotBlock

      blk = RangeProfilePlotBlock
    range_bin_step: range_bin_step
    range_roi: range_roi
    vlen_in: fft_len*zeropadding_fac
  states: {}
- name: scheduled_rx_bind_snippet
  id: snippet
  parameters:
    code: |
      import time
      from gnuradio import uhd
      now = time.time()
      self.uhd_usrp_sink_0.set_time_now(uhd.time_spec(now), uhd.ALL_MBOARDS)
      self.uhd_usrp_source_0.set_time_now(uhd.time_spec(now), uhd.ALL_MBOARDS)
      self.burst_iq_tag_tx_0.bind_scheduled_rx(self.uhd_usrp_source_0)
    comment: Bind USRP Source for scheduled NUM_SAMPS_AND_DONE RX
    section: main_after_init
  states: {}
- name: sionna_ofdm_modulator_0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.sionna_ofdm_modulator import SionnaOfdmModulatorBlock

      blk = SionnaOfdmModulatorBlock
    burst_len_samples: burst_len_samples
    comment: Python IFFT+CP (replaces fft_vxx + cyclic_prefixer)
    cp_len: fft_len//4
    device: '''cpu'''
    fft_len: fft_len
    length_tag_key: length_tag_key
    minoutbuf: burst_len_samples
    num_bits_per_symbol: '2'
    seed: '42'
    subcarrier_spacing: subcarrier_spacing
    target_peak: '1.0'
    transpose_len: transpose_len
  states: {}
- name: sionna_resource_grid_tx_0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.sionna_resource_grid_tx import SionnaResourceGridTxBlock

      blk = SionnaResourceGridTxBlock
    cp_len: fft_len//4
    device: '''cpu'''
    fft_len: fft_len
    length_tag_key: length_tag_key
    minoutbuf: 4*transpose_len
    num_bits_per_symbol: '2'
    seed: '42'
    subcarrier_spacing: subcarrier_spacing
    transpose_len: transpose_len
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    clock_rate: '0'
    clock_source0: internal
    dev_addr: address
    dev_args: '""'
    gain0: TX_gain
    len_tag_name: ''
    samp_rate: samp_rate
    stream_args: num_send_frames=512,send_buff_size=25000000
    stream_chans: '[0]'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    center_freq0: freq
    clock_rate: '0'
    clock_source0: internal
    dev_addr: address
    dev_args: '""'
    gain0: RX_gain
    minoutbuf: min_out_buf_val
    samp_rate: samp_rate
    stream_args: num_recv_frames=512,recv_buff_size=25000000
    stream_chans: '[0]'
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', burst_iq_tag_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [burst_iq_tag_tx_0, '0', uhd_usrp_sink_0, '0']
- [burst_iq_tag_tx_0, tx_schedule, ofdm_range_profile_0, tx_schedule]
- [cpi_rate_probe_0, '0', qtgui_freq_sink_x_0, '0']
- [cpi_rate_probe_0, '0', radar_ofdm_cyclic_prefix_remover_cvc_0, '0']
- [sionna_ofdm_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [echotimer_rx_compensator_0, '0', cpi_rate_probe_0, '0']
- [fft_vxx_0_0, '0', ofdm_cpi_tag_normalizer_rx_0, '0']
- [ofdm_cpi_tag_normalizer_rx_0, '0', ofdm_range_profile_0, '1']
- [ofdm_range_profile_0, '0', range_profile_plot_dev1, '0']
- [ofdm_range_profile_0, '1', range_music_block_dev1, '0']
- [packet_len_tagger_0, '0', echotimer_rx_compensator_0, '0']
- [radar_ofdm_cyclic_prefix_remover_cvc_0, '0', fft_vxx_0_0, '0']
- [sionna_resource_grid_tx_0, '0', sionna_ofdm_modulator_0, '0']
- [sionna_resource_grid_tx_0, '0', ofdm_range_profile_0, '0']
- [uhd_usrp_source_0, '0', packet_len_tagger_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
