options:
  parameters:
    category: Custom
    description: OFDM radar simulator zero-Doppler range profile (full 0~R_max). Range spectrum via qtgui_vector_sink_f.
    generate_options: qt_gui
    id: simulator_ofdm
    output_language: python
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: subcarrier_spacing
  id: variable
  parameters:
    value: 60e3
  states: {}
- name: zeropadding_fac
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(fft_len * subcarrier_spacing)
  states: {}
- name: R_max
  id: variable
  parameters:
    comment: 最大不模糊距离 (m)，R = c/(2·BW)·N_fft
    value: 3e8/2/samp_rate*fft_len
  states: {}
- name: range_bin_step
  id: variable
  parameters:
    comment: 距离谱横轴步进 (m/bin)；GRC 显示 305.176m = 0.305 m
    value: 3e8/(2*int(fft_len*subcarrier_spacing)*zeropadding_fac)
  states: {}
- name: factor
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.004'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: 载频 (Hz)；须与 v_max 公式一致，否则速度估计会偏
    value: 6.0e9
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: n_carriers
  id: variable
  parameters:
    comment: occupied subcarriers (full band minus DC); matches gr_setup.resolve_gr_carrier_tuples
    value: fft_len - 2
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: list((list(range(-n_carriers//2, 0)) + list(range(1, n_carriers//2 + 1)),))
  states: {}
- name: packet_len
  id: variable
  parameters:
    comment: QPSK bytes per burst; derived from CPI symbol count
    value: transpose_len * n_carriers // 4
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: qpsk_symbols_per_packet
  id: variable
  parameters:
    comment: QPSK complex symbols per burst after repack_bits
    value: transpose_len * n_carriers
  states: {}
- name: transpose_len
  id: variable
  parameters:
    comment: CPI OFDM symbols per burst; 4 avoids qpsk>8192 sched limit at fft_len=2048
    value: '4'
  states: {}
- name: v_max
  id: variable
  parameters:
    comment: 最大不模糊速度 (m/s)，v = c/(4·fc·T_sym)
    value: 3e8/(4*freq*(fft_len+fft_len/4)/samp_rate)
  states: {}
- name: value_range
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: range
    start: '0.1'
    step: '1'
    stop: R_max
    value: '100'
  states: {}
- name: velocity
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: Velocity
    start: '-v_max'
    step: '1'
    stop: v_max
    value: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: packet_len
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    comment: Non-coherent sum over CPI symbols (decim=transpose_len)
    decim: transpose_len
    type: float
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: factor
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
    minoutbuf: 2*qpsk_symbols_per_packet
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    minoutbuf: 2*qpsk_symbols_per_packet
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    comment: Buffer full CPI packets for CP remover (>8192 samples at fft_len=2048)
    lengthtagname: '"packet_len"'
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    minoutbuf: 2*qpsk_symbols_per_packet
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    minoutbuf: 4*transpose_len
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: ((),)
    pilot_symbols: ((),)
    sync_words: ()
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    tagname: length_tag_key
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    minoutbuf: 2*transpose_len
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    minoutbuf: 2*transpose_len
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_len*zeropadding_fac
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_len*zeropadding_fac)
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    comment: Zero-Doppler range profile, 0~R_max m (full spectrum)
    grid: 'True'
    label1: Range Profile
    name: '"Range Profile"'
    vlen: fft_len*zeropadding_fac
    x_axis_label: '"Range"'
    x_start: '0'
    x_step: range_bin_step
    x_units: '"m"'
    y_axis_label: '"Power (dB)"'
    y_units: '"dB"'
    ymax: '0'
    ymin: '-40'
  states: {}
- name: radar_ofdm_cyclic_prefix_remover_cvc_0
  id: radar_ofdm_cyclic_prefix_remover_cvc
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
  states: {}
- name: radar_ofdm_divide_vcvc_0
  id: radar_ofdm_divide_vcvc
  parameters:
    discarded_carriers: ()
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
    num_sync_words: '0'
    vlen_in: fft_len
    vlen_out: (fft_len)*zeropadding_fac
  states: {}
- name: radar_static_target_simulator_cc_0
  id: radar_static_target_simulator_cc
  parameters:
    azimuth: '0'
    center_freq: freq
    len_key: '"packet_len"'
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    position_rx: '0'
    range: value_range
    rcs: 1e25
    rndm_phaseshift: 'True'
    samp_rate: samp_rate
    self_coupling: 'True'
    self_coupling_db: '-10'
    velocity: velocity
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', blocks_tagged_stream_align_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', radar_static_target_simulator_cc_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_tagged_stream_align_0, '0', radar_ofdm_cyclic_prefix_remover_cvc_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', radar_ofdm_divide_vcvc_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_vxx_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', radar_ofdm_divide_vcvc_0, '1']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_squared_0, '0']
- [radar_ofdm_cyclic_prefix_remover_cvc_0, '0', fft_vxx_0_0, '0']
- [radar_ofdm_divide_vcvc_0, '0', fft_vxx_0_1, '0']
- [radar_static_target_simulator_cc_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
