options:
  parameters:
    author: Example
    category: Custom
    description: Loopback test
    generate_options: qt_gui
    id: uhd_two_tone_loopback
    output_language: python
    title: UHD Loopback - 2 Tone
  states: {}

blocks:
- name: RX_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: rx_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: TX_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: tx_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: min_out_buf_val
  id: variable
  parameters:
    value: packet_len*2
  states: {}
- name: num_delay_samp
  id: variable_qtgui_range
  parameters:
    label: Number of delayed samples
    start: '0'
    step: '1'
    stop: packet_len
    value: '750'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: wait_samp+send_samp
  states: {}
- name: send_samp
  id: variable
  parameters:
    value: '400'
  states: {}
- name: wait_samp
  id: variable
  parameters:
    value: '800'
  states: {}
- name: address
  id: parameter
  parameters:
    label: UHD dev args
    type: str
    value: '"type=x4xx,mgmt_addr=192.168.1.100,addr=192.168.10.2"'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: num_delay_samp
    type: complex
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Default Frequency
    short_id: f
    type: eng_float
    value: 6.0e9
  states: {}
- name: freq_offset
  id: parameter
  parameters:
    label: Rx Frequency Offset
    short_id: o
    type: eng_float
    value: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: radar_signal_generator_sync_pulse_c_0
  id: radar_signal_generator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    minoutbuf: min_out_buf_val
    packet_len: packet_len
    pulse_amplitude: '0.8'
    pulse_len: send_samp
    pulse_pause: wait_samp
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 500e3
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    clock_rate: '0'
    dev_addr: address
    dev_args: '""'
    gain0: TX_gain
    len_tag_name: ''
    samp_rate: samp_rate
    stream_args: num_send_frames=512,send_buff_size=25000000
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    center_freq0: freq
    clock_rate: '0'
    dev_addr: address
    dev_args: '""'
    gain0: RX_gain
    minoutbuf: '262144'
    samp_rate: samp_rate
    stream_args: num_recv_frames=512,recv_buff_size=25000000
    stream_chans: '[2]'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0, '0', blocks_complex_to_mag_1, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', blocks_complex_to_mag_0, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', uhd_usrp_sink_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
