options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: sensing_baseline
    output_language: python
    run_command: /home/caict/radioconda/envs/ISAC/bin/python -u run_sensing_baseline_grc.py
  states: {}

blocks:
- name: burst_mode
  id: variable
  parameters:
    comment: Style 1 burst 门控（Channel/Rx tag）
    value: 'True'
  states: {}
- name: idle_ms
  id: variable
  parameters:
    comment: Style 1 静默间隔 (ms)，与 style1_usrp_txrx 一致
    value: '400'
  states: {}
- name: time_lead_s
  id: variable
  parameters:
    comment: tx_time tag 提前量 [s]，与 style1_usrp_txrx 一致
    value: '0.05'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: 载频 (Hz)
    value: 3.5e9
  states: {}
- name: config_file
  id: variable
  parameters:
    comment: Sionna TOML 路径
    value: '"config/simulation/sensing/sensing_baseline.toml"'
  states: {}
- name: cp_len
  id: variable
  parameters:
    comment: 循环前缀 (samples)
    value: '0'
  states: {}
- name: fft_len
  id: variable
  parameters:
    comment: num_subcarriers
    value: '1024'
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: ofdm_symbols
  id: variable
  parameters:
    comment: num_symbols / 慢时间 FFT 长度
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: fft_len * subcarrier_spacing
    value: int(fft_len * subcarrier_spacing)
  states: {}
- name: snr_db
  id: variable
  parameters:
    comment: 接收 SNR (dB)，与 sensing_baseline.toml 默认一致
    value: '-5'
  states: {}
- name: spectrogram_interval
  id: variable
  parameters:
    comment: Qt 谱图刷新 (ms)；Style 1 burst 须晚于首帧 GPU RT+DD
    value: max(180000, int((idle_ms + 1000.0*ofdm_symbols*(fft_len+cp_len)/samp_rate) * 600))
  states: {}
- name: subcarrier_spacing
  id: variable
  parameters:
    comment: 子载波间隔 (Hz)
    value: '30000.0'
  states: {}
- name: tx_device
  id: variable
  parameters:
    comment: Sionna 计算设备
    value: '"cuda:0"'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: 消费 Sionna DD Rx out(0) complex[fft_len]
    type: complex
    vlen: fft_len
  states: {}
- name: import_0
  id: import
  parameters:
    imports: |-
      import numpy as np
      import sys
      import os
      from pathlib import Path
      _GRC_DIR = os.path.dirname(os.path.abspath(__file__)) if '__file__' in dir() else os.getcwd()
      _REPO = str(Path(_GRC_DIR).parent)
      _SRC = _REPO + '/src'
      for _p in (_GRC_DIR, _SRC):
          if _p not in sys.path:
              sys.path.insert(0, _p)
      # 调参优先改 GRC 变量；Sionna 块内 merge_config(TOML, GRC) 覆盖同名字段
  states: {}
- name: radar_qtgui_spectrogram_plot_0
  id: radar_qtgui_spectrogram_plot
  parameters:
    autoscale_z: 'True'
    axis_x: '[0, 10000]'
    axis_y: '[-150, 150]'
    axis_z: '[-15,-12]'
    comment: DD 谱图；精确 R_max/v_max 由 merge_config 打印
    interval: spectrogram_interval
    label: '''ISAC Baseline DD'''
    len_key: '"packet_len"'
    vlen: fft_len
    xlabel: '''target_range'''
    ylabel: '''target_velocity'''
  states: {}
- name: sionna_bootstrap_0
  id: sionna_bootstrap
  parameters:
    center_freq: center_freq
    comment: GPU 预热 + 感知性能打印（须先于 Sionna TX/RX/Channel 实例化）
    config_file: config_file
    cp_len: cp_len
    device: tx_device
    fft_len: fft_len
    ofdm_symbols: ofdm_symbols
    seed: '42'
    subcarrier_spacing: subcarrier_spacing
  states: {}
- name: sionna_dd_rx_0
  id: sionna_dd_rx
  parameters:
    burst_mode: burst_mode
    center_freq: center_freq
    config_file: config_file
    cp_len: cp_len
    device: tx_device
    fft_len: fft_len
    length_tag_key: length_tag_key
    log_eps: '1e-20'
    mininbuf: int(2*ofdm_symbols*(fft_len+max(cp_len, 0)))
    minoutbuf: int(2*ofdm_symbols)
    ofdm_symbols: ofdm_symbols
    seed: '42'
    subcarrier_spacing: subcarrier_spacing
  states: {}
- name: sionna_ofdm_tx_0
  id: sionna_ofdm_tx
  parameters:
    center_freq: center_freq
    config_file: config_file
    cp_len: cp_len
    device: tx_device
    fft_len: fft_len
    idle_ms: idle_ms
    length_tag_key: length_tag_key
    minoutbuf: int(2*ofdm_symbols*(fft_len+max(cp_len, 0)))
    ofdm_symbols: ofdm_symbols
    samp_rate: samp_rate
    seed: '42'
    subcarrier_spacing: subcarrier_spacing
    time_lead_s: time_lead_s
    uhd_burst_tags: 'True'
  states: {}
- name: sionna_rt_channel_0
  id: sionna_rt_channel
  parameters:
    burst_mode: burst_mode
    center_freq: center_freq
    comment: RT 射线追踪信道（System.components.channel time 域）
    config_file: config_file
    cp_len: cp_len
    device: tx_device
    fft_len: fft_len
    length_tag_key: length_tag_key
    minoutbuf: int(2*ofdm_symbols)
    ofdm_symbols: ofdm_symbols
    seed: '42'
    snr_db: snr_db
    subcarrier_spacing: subcarrier_spacing
  states: {}

connections:
- [sionna_dd_rx_0, '0', blocks_null_sink_0, '0']
- [sionna_dd_rx_0, '1', radar_qtgui_spectrogram_plot_0, '0']
- [sionna_ofdm_tx_0, '0', sionna_rt_channel_0, '0']
- [sionna_rt_channel_0, '0', sionna_dd_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
