options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: usrp_ofdm_echotimer_dd
    output_language: python
  states: {}

blocks:
- name: R_max
  id: variable
  parameters:
    value: 3e8/2/samp_rate*fft_len
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '6000000000'
  states: {}
- name: discarded_carriers
  id: variable
  parameters:
    value: '[]'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: 2**6
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: min_out_buf_val
  id: variable
  parameters:
    value: int(2*transpose_len*(fft_len+fft_len/4))
  states: {}
- name: num_delay_samp
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2
    label: num_delay_samp
    start: '0'
    step: '1'
    stop: packet_len
    value: '0'
  states: {}
- name: occupied_carriers_all
  id: variable
  parameters:
    value: list((range(-26,27),))
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 2**9
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3
    label: RX Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5120000'
  states: {}
- name: spectrogram_interval
  id: variable
  parameters:
    comment: ms; must exceed first DD frame delay on echotimer hardware
    value: max(5000, int(1000 * (wait_to_start + 2*transpose_len*(fft_len+fft_len//4)/samp_rate + 2.0)))
  states: {}
- name: transpose_len
  id: variable
  parameters:
    value: int(np.ceil(packet_len*4.0/len(occupied_carriers_all[0])))
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4
    label: TX Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: uhd_dev_args
  id: variable
  parameters:
    comment: 'X410: RJ45 mgmt 1.100 + QSFP sfp0 10.2; host needs 192.168.10.1 on enp1s0f0np0'
    value: '"type=x4xx,mgmt_addr=192.168.1.100,addr=192.168.10.2"'
  states: {}
- name: v_max
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    comment: seconds before timed TX/RX in echotimer
    value: '0.03'
  states: {}
- name: burst_pri_s
  id: variable
  parameters:
    comment: OFDM CPI air time + wait_to_start
    value: wait_to_start + transpose_len*(fft_len+fft_len//4)/samp_rate
  states: {}
- name: burst_byte_rate
  id: variable
  parameters:
    comment: byte/s; one packet_len tag per burst PRI (not samp_rate throttle)
    value: packet_len/burst_pri_s
  states: {}
- name: uhd_timeout_s
  id: variable
  parameters:
    comment: UHD send/recv timeout margin for echotimer
    value: '1.0'
  states: {}
- name: zeropadding_fac
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Packet-rate pacing for echotimer PRI (bytes/s, not RF samp_rate)
    samples_per_second: burst_byte_rate
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_dd_0
  id: blocks_tag_debug
  parameters:
    comment: DD log-magnitude diagnostic before spectrogram
    name: DD output
    type: float
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_tag_debug_rx_0
  id: blocks_tag_debug
  parameters:
    comment: RX IQ diagnostic from echotimer
    name: RX echotimer
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    minoutbuf: 2*packet_len*4
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    minoutbuf: 2*transpose_len
    occupied_carriers: occupied_carriers_all
    output_is_shifted: 'True'
    pilot_carriers: ((),)
    pilot_symbols: ((),)
    sync_words: ()
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    tagname: length_tag_key
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    minoutbuf: 2*transpose_len
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_len*zeropadding_fac
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_len*zeropadding_fac)
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    fft_size: transpose_len
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.blackmanharris(transpose_len)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: radar_estimator_ofdm_0
  id: radar_estimator_ofdm
  parameters:
    axis_x: '[0,R_max]'
    axis_y: '[0,v_max,-v_max,0]'
    len_x: fft_len*zeropadding_fac
    len_y: transpose_len
    merge_consecutive: 'True'
    symbol_x: '''range'''
    symbol_y: '''velocity'''
  states: {}
- name: radar_ofdm_cyclic_prefix_remover_cvc_0
  id: radar_ofdm_cyclic_prefix_remover_cvc
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
  states: {}
- name: radar_ofdm_divide_vcvc_0
  id: radar_ofdm_divide_vcvc
  parameters:
    discarded_carriers: ()
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
    num_sync_words: '0'
    vlen_in: fft_len
    vlen_out: (fft_len-len(discarded_carriers))*zeropadding_fac
  states: {}
- name: radar_os_cfar_2d_vc_0
  id: radar_os_cfar_2d_vc
  parameters:
    len_key: '"packet_len"'
    mult_threshold: '30'
    rel_threshold: '0.78'
    samp_compare: '[10,10]'
    samp_protect: '[0,0]'
    vlen: fft_len*zeropadding_fac
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_qtgui_spectrogram_plot_0
  id: radar_qtgui_spectrogram_plot
  parameters:
    autoscale_z: 'True'
    axis_x: '[0,R_max]'
    axis_y: '[0,v_max]'
    axis_z: '[-15,-12]'
    interval: spectrogram_interval
    label: '''OFDM Radar'''
    len_key: '"packet_len"'
    vlen: fft_len*zeropadding_fac
    xlabel: '''value_range'''
    ylabel: '''Velocity'''
  states: {}
- name: radar_transpose_matrix_vcvc_0
  id: radar_transpose_matrix_vcvc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: 2*fft_len*zeropadding_fac
    vlen_in: fft_len*zeropadding_fac
    vlen_out: transpose_len
  states: {}
- name: radar_transpose_matrix_vcvc_0_0
  id: radar_transpose_matrix_vcvc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
    vlen_in: transpose_len
    vlen_out: fft_len*zeropadding_fac
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    antenna_rx: '''RX1'''
    antenna_tx: '''TX/RX'''
    args_rx: uhd_dev_args
    args_tx: uhd_dev_args
    center_freq: center_freq
    channel_rx: '0'
    channel_tx: '0'
    clock_source_rx: '''internal'''
    gain_rx: rx_gain
    gain_tx: tx_gain
    minoutbuf: min_out_buf_val
    num_delay_samps: int(num_delay_samp)
    samp_rate: samp_rate
    time_source_rx: '''internal'''
    time_source_tx: '''internal'''
    timeout_rx: uhd_timeout_s
    timeout_tx: uhd_timeout_s
    wait_rx: wait_to_start
    wait_tx: wait_to_start
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_null_sink_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_tag_debug_dd_0, '0']
- [blocks_nlog10_ff_0, '0', radar_qtgui_spectrogram_plot_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', radar_ofdm_divide_vcvc_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', radar_usrp_echotimer_cc_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', radar_ofdm_divide_vcvc_0, '1']
- [fft_vxx_0_1, '0', radar_transpose_matrix_vcvc_0, '0']
- [fft_vxx_0_1_0, '0', radar_transpose_matrix_vcvc_0_0, '0']
- [radar_estimator_ofdm_0, Msg out, radar_print_results_0, Msg in]
- [radar_ofdm_cyclic_prefix_remover_cvc_0, '0', fft_vxx_0_0, '0']
- [radar_ofdm_divide_vcvc_0, '0', fft_vxx_0_1, '0']
- [radar_os_cfar_2d_vc_0, Msg out, radar_estimator_ofdm_0, Msg in]
- [radar_transpose_matrix_vcvc_0, '0', fft_vxx_0_1_0, '0']
- [radar_transpose_matrix_vcvc_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [radar_transpose_matrix_vcvc_0_0, '0', radar_os_cfar_2d_vc_0, '0']
- [radar_usrp_echotimer_cc_0, '0', blocks_tag_debug_rx_0, '0']
- [radar_usrp_echotimer_cc_0, '0', radar_ofdm_cyclic_prefix_remover_cvc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
