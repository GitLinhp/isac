options:
  parameters:
    description: Dual-USRP cooperative monostatic OFDM range profile collection; both devices TX+RX simultaneously (aligned with usrp_ofdm_echotimer_dd_seperate).
    generate_options: qt_gui
    id: data_collection_cooperative_monostatic
    output_language: python
    title: Cooperative monostatic sensing data collection
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: subcarrier_spacing
  id: variable
  parameters:
    value: 120e3
  states: {}
- name: zeropadding_fac
  id: variable
  parameters:
    value: '2'
  states: {}
- name: transpose_len
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Shared sample rate for both USRP devices and baseband chain
    value: int(fft_len * subcarrier_spacing)
  states: {}
- name: n_carriers
  id: variable
  parameters:
    value: fft_len - 2
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: transpose_len * n_carriers // 4
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: burst_len_samples
  id: variable
  parameters:
    value: transpose_len * (fft_len + fft_len//4)
  states: {}
- name: min_out_buf_val
  id: variable
  parameters:
    value: packet_len*2
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: device
  id: variable
  parameters:
    value: '"cpu"'
  states: {}
- name: factor
  id: variable
  parameters:
    value: '0.008'
  states: {}
- name: range_roi
  id: variable
  parameters:
    value: (0.0, 30.0)
  states: {}
- name: range_bin_step
  id: variable
  parameters:
    value: 3e8/(2*int(fft_len*subcarrier_spacing)*zeropadding_fac)
  states: {}
- name: R_max
  id: variable
  parameters:
    value: 3e8/2/samp_rate*fft_len
  states: {}
- name: freq0
  id: variable
  parameters:
    value: 6.03e9
  states: {}
- name: freq1
  id: variable
  parameters:
    value: 5.97e9
  states: {}
- name: record_enable
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: record_max_frames
  id: variable
  parameters:
    value: '100'
  states: {}
- name: record_output_dir_dev0
  id: variable
  parameters:
    value: repo_data_dir("data", "experiment", "cooperative_monostatic", "dev0")
  states: {}
- name: record_output_dir_dev1
  id: variable
  parameters:
    value: repo_data_dir("data", "experiment", "cooperative_monostatic", "dev1")
  states: {}
- name: record_file_path_dev0
  id: variable
  parameters:
    value: '"/dev/null"'
  states: {}
- name: record_file_path_dev1
  id: variable
  parameters:
    value: '"/dev/null"'
  states: {}
- name: record_output_index_dev0
  id: variable
  parameters:
    value: 0 if record_enable else 1
  states: {}
- name: record_output_index_dev1
  id: variable
  parameters:
    value: 0 if record_enable else 1
  states: {}
- name: music_enable
  id: variable_qtgui_check_box
  parameters:
    comment: Enable 1D range MUSIC super-resolution on CPI complex range profile (dev0+dev1)
    'false': 'False'
    gui_hint: 0,4,1,1
    label: MUSIC Enable
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: address0
  id: parameter
  parameters:
    comment: USRP dev0
    label: address0 (33ABFDE)
    type: str
    value: type=x4xx,serial=33ABFDE,mgmt_addr=192.168.1.101,addr=192.168.11.2,clock_source=external,time_source=external
  states: {}
- name: address1
  id: parameter
  parameters:
    comment: USRP dev1
    label: address1 (349B642)
    type: str
    value: type=x4xx,serial=349B642,mgmt_addr=192.168.1.100,addr=192.168.10.2,clock_source=external,time_source=external
  states: {}
- name: TX_gain0
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    label: TX Gain
    start: '0'
    step: '1'
    stop: packet_len
    value: '20'
  states: {}
- name: RX_gain0
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,3,1,1
    label: RX Gain
    start: '0'
    step: '1'
    stop: packet_len
    value: '20'
  states: {}
- name: num_delay_samp0
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Number of delayed samples
    start: '0'
    step: '1'
    stop: packet_len
    value: '282'
  states: {}
- name: TX_gain1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: TX Gain
    start: '0'
    step: '1'
    stop: packet_len
    value: '20'
  states: {}
- name: RX_gain1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: RX Gain
    start: '0'
    step: '1'
    stop: packet_len
    value: '20'
  states: {}
- name: num_delay_samp1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Number of delayed samples
    start: '0'
    step: '1'
    stop: packet_len
    value: '282'
  states: {}
- name: import_mics_test_record_flow_0
  id: import
  parameters:
    comment: record limit + auto-stop hooks
    imports: |-
      from isac_imp.mics_test_record_flow import install_mics_test_record_flow
      from isac_imp.record_paths import repo_data_dir
  states: {}
- name: snippet_install_record_flow_0
  id: snippet
  parameters:
    code: install_mics_test_record_flow(self)
    comment: Bind record limit handler after top block init
    priority: '10'
    section: main_after_init
  states: {}
- name: sionna_resource_grid_tx
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.sionna_resource_grid_tx import SionnaResourceGridTxBlock

      blk = SionnaResourceGridTxBlock
    fft_len: fft_len
    transpose_len: transpose_len
    subcarrier_spacing: subcarrier_spacing
    cp_len: fft_len//4
    length_tag_key: length_tag_key
    num_bits_per_symbol: '2'
    device: device
    seed: '42'
    minoutbuf: 4*transpose_len
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    window: ()
    shift: 'True'
    type: complex
    minoutbuf: 2*transpose_len
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    input_size: fft_len
    cp_len: fft_len//4
    tagname: length_tag_key
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: factor
    type: complex
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
  states: {}
- name: radar_usrp_echotimer_cc_0_0
  id: radar_usrp_echotimer_cc
  parameters:
    samp_rate: int(samp_rate)
    center_freq: freq0
    num_delay_samps: int(num_delay_samp0)
    args_tx: address0
    channel_tx: '0'
    wire_tx: ''
    clock_source_tx: external
    time_source_tx: external
    antenna_tx: TX/RX
    gain_tx: TX_gain0
    timeout_tx: '0.2'
    wait_tx: wait_to_start
    args_rx: address0
    channel_rx: '0'
    wire_rx: ''
    clock_source_rx: external
    time_source_rx: external
    antenna_rx: RX1
    gain_rx: RX_gain0
    timeout_rx: '0.2'
    wait_rx: wait_to_start
    minoutbuf: min_out_buf_val
  states: {}
- name: radar_ofdm_cyclic_prefix_remover_cvc_0_0
  id: radar_ofdm_cyclic_prefix_remover_cvc
  parameters:
    fft_len: fft_len
    cp_len: fft_len//4
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
  states: {}
- name: fft_rx_dev0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    window: ()
    shift: 'True'
    type: complex
    minoutbuf: 2*transpose_len
  states: {}
- name: qtgui_freq_sink_x_dev0
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: ''
    srate: samp_rate
    fc: '0'
    bw: samp_rate
    fftsize: fft_len
  states: {}
- name: ofdm_range_profile_dev0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.ofdm_range_profile import OfdmRangeProfileBlock

      blk = OfdmRangeProfileBlock
    fft_len: fft_len
    zeropadding_fac: zeropadding_fac
    transpose_len: transpose_len
  states: {}
- name: range_profile_plot_dev0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.range_profile_plot import RangeProfilePlotBlock

      blk = RangeProfilePlotBlock
    vlen_in: fft_len*zeropadding_fac
    range_roi: range_roi
    range_bin_step: range_bin_step
  states: {}
- name: range_music_block_dev0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.range_music_block import RangeMusicBlock

      blk = RangeMusicBlock
    vlen_in: fft_len*zeropadding_fac
    range_bin_step: range_bin_step
    range_roi: range_roi
    num_sources: '1'
    music_enable: music_enable
    subarray_size: '16'
    threshold: '0.1'
  states: {}
- name: range_profile_record_limiter_dev0
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.range_profile_record_limiter import RangeProfileRecordLimiter

      blk = RangeProfileRecordLimiter
    vlen_in: fft_len*zeropadding_fac
    record_enable: record_enable
    record_max_frames: int(record_max_frames)
    record_output_dir_override: record_output_dir_dev0
    file_sink_attr: '"blocks_file_sink_dev0"'
    record_file_path_attr: '"record_file_path_dev0"'
  states: {}
- name: blocks_selector_dev0
  id: blocks_selector
  parameters:
    type: complex
    num_inputs: '1'
    output_index: record_output_index_dev0
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_file_sink_dev0
  id: blocks_file_sink
  parameters:
    type: complex
    vlen: fft_len*zeropadding_fac
    file: record_file_path_dev0
  states: {}
- name: blocks_null_sink_rec_dev0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: fft_len*zeropadding_fac
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    samp_rate: int(samp_rate)
    center_freq: freq1
    num_delay_samps: int(num_delay_samp1)
    args_tx: address1
    channel_tx: '0'
    wire_tx: ''
    clock_source_tx: external
    time_source_tx: external
    antenna_tx: TX/RX
    gain_tx: TX_gain1
    timeout_tx: '0.2'
    wait_tx: wait_to_start
    args_rx: address1
    channel_rx: '0'
    wire_rx: ''
    clock_source_rx: external
    time_source_rx: external
    antenna_rx: RX1
    gain_rx: RX_gain1
    timeout_rx: '0.2'
    wait_rx: wait_to_start
    minoutbuf: min_out_buf_val
  states: {}
- name: radar_ofdm_cyclic_prefix_remover_cvc_0
  id: radar_ofdm_cyclic_prefix_remover_cvc
  parameters:
    fft_len: fft_len
    cp_len: fft_len//4
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
  states: {}
- name: fft_rx_dev1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    window: ()
    shift: 'True'
    type: complex
    minoutbuf: 2*transpose_len
  states: {}
- name: qtgui_freq_sink_x_dev1
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: ''
    srate: samp_rate
    fc: '0'
    bw: samp_rate
    fftsize: fft_len
  states: {}
- name: ofdm_range_profile_dev1
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.ofdm_range_profile import OfdmRangeProfileBlock

      blk = OfdmRangeProfileBlock
    fft_len: fft_len
    zeropadding_fac: zeropadding_fac
    transpose_len: transpose_len
  states: {}
- name: range_profile_plot_dev1
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.range_profile_plot import RangeProfilePlotBlock

      blk = RangeProfilePlotBlock
    vlen_in: fft_len*zeropadding_fac
    range_roi: range_roi
    range_bin_step: range_bin_step
  states: {}
- name: range_music_block_dev1
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.range_music_block import RangeMusicBlock

      blk = RangeMusicBlock
    vlen_in: fft_len*zeropadding_fac
    range_bin_step: range_bin_step
    range_roi: range_roi
    num_sources: '1'
    music_enable: music_enable
    subarray_size: '16'
    threshold: '0.1'
  states: {}
- name: range_profile_record_limiter_dev1
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.range_profile_record_limiter import RangeProfileRecordLimiter

      blk = RangeProfileRecordLimiter
    vlen_in: fft_len*zeropadding_fac
    record_enable: record_enable
    record_max_frames: int(record_max_frames)
    record_output_dir_override: record_output_dir_dev1
    file_sink_attr: '"blocks_file_sink_dev1"'
    record_file_path_attr: '"record_file_path_dev1"'
  states: {}
- name: blocks_selector_dev1
  id: blocks_selector
  parameters:
    type: complex
    num_inputs: '1'
    output_index: record_output_index_dev1
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_file_sink_dev1
  id: blocks_file_sink
  parameters:
    type: complex
    vlen: fft_len*zeropadding_fac
    file: record_file_path_dev1
  states: {}
- name: blocks_null_sink_rec_dev1
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: fft_len*zeropadding_fac
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: ''
    srate: samp_rate
    size: fft_len + fft_len//4
  states: {}

connections:
- [sionna_resource_grid_tx, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', radar_usrp_echotimer_cc_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', radar_usrp_echotimer_cc_0, '0']
- [sionna_resource_grid_tx, '0', ofdm_range_profile_dev0, '0']
- [sionna_resource_grid_tx, '0', ofdm_range_profile_dev1, '0']
- [radar_usrp_echotimer_cc_0_0, '0', qtgui_freq_sink_x_dev0, '0']
- [radar_usrp_echotimer_cc_0_0, '0', radar_ofdm_cyclic_prefix_remover_cvc_0_0, '0']
- [radar_ofdm_cyclic_prefix_remover_cvc_0_0, '0', fft_rx_dev0, '0']
- [fft_rx_dev0, '0', ofdm_range_profile_dev0, '1']
- [ofdm_range_profile_dev0, '0', range_profile_plot_dev0, '0']
- [ofdm_range_profile_dev0, '1', range_music_block_dev0, '0']
- [ofdm_range_profile_dev0, '1', range_profile_record_limiter_dev0, '0']
- [range_profile_record_limiter_dev0, '0', blocks_selector_dev0, '0']
- [blocks_selector_dev0, '0', blocks_file_sink_dev0, '0']
- [blocks_selector_dev0, '1', blocks_null_sink_rec_dev0, '0']
- [radar_usrp_echotimer_cc_0, '0', qtgui_freq_sink_x_dev1, '0']
- [radar_usrp_echotimer_cc_0, '0', radar_ofdm_cyclic_prefix_remover_cvc_0, '0']
- [radar_ofdm_cyclic_prefix_remover_cvc_0, '0', fft_rx_dev1, '0']
- [fft_rx_dev1, '0', ofdm_range_profile_dev1, '1']
- [ofdm_range_profile_dev1, '0', range_profile_plot_dev1, '0']
- [ofdm_range_profile_dev1, '1', range_music_block_dev1, '0']
- [ofdm_range_profile_dev1, '1', range_profile_record_limiter_dev1, '0']
- [range_profile_record_limiter_dev1, '0', blocks_selector_dev1, '0']
- [blocks_selector_dev1, '0', blocks_file_sink_dev1, '0']
- [blocks_selector_dev1, '1', blocks_null_sink_rec_dev1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
