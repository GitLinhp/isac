options:
  parameters:
    description: OFDM range profile with 1D MUSIC via OfdmRangeProfileBlock out1 + RangeMusicBlock; optional CPI complex range-profile recording to disk
    generate_options: qt_gui
    id: data_collection_monostatic
    output_language: python
    title: Monostatic sensing data collection
  states: {}

blocks:
- name: RX_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: R_max
  id: variable
  parameters:
    comment: 最大不模糊距离 (m)，R = c/(2·BW)·N_fft
    value: 3e8/2/samp_rate*fft_len
  states: {}
- name: TX_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: burst_len_samples
  id: variable
  parameters:
    comment: CPI time-domain samples; transpose_len * (fft_len + fft_len//4)
    value: transpose_len * (fft_len + fft_len//4)
  states: {}
- name: device
  id: variable
  parameters:
    value: '"cpu"'
  states: {}
- name: factor
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.008'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: 载频 (Hz)；须与 v_max 公式一致，否则速度估计会偏
    value: 6.0e9
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: min_out_buf_val
  id: variable
  parameters:
    value: packet_len*2
  states: {}
- name: music_enable
  id: variable_qtgui_check_box
  parameters:
    comment: Enable 1D range MUSIC super-resolution on CPI complex range profile
    'false': 'False'
    gui_hint: 0,4,1,1
    label: MUSIC Enable
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: n_carriers
  id: variable
  parameters:
    comment: occupied subcarriers (full band minus DC); matches gr_setup.resolve_gr_carrier_tuples
    value: fft_len - 2
  states: {}
- name: num_delay_samp
  id: variable_qtgui_range
  parameters:
    comment: Recalibrate after fft_len/rate change; align loopback peak to 0 m
    label: Number of delayed samples
    start: '0'
    step: '1'
    stop: packet_len
    value: '282'
  states: {}
- name: packet_len
  id: variable
  parameters:
    comment: QPSK bytes per burst; derived from CPI symbol count
    value: transpose_len * n_carriers // 4
  states: {}
- name: range_bin_step
  id: variable
  parameters:
    comment: 距离谱横轴步进 (m/bin)；GRC 显示 305.176m = 0.305 m
    value: 3e8/(2*int(fft_len*subcarrier_spacing)*zeropadding_fac)
  states: {}
- name: range_roi
  id: variable
  parameters:
    comment: ROI display range (min_m, max_m) for range profile GUI
    value: (0.0, 30.0)
  states: {}
- name: record_enable
  id: variable_qtgui_check_box
  parameters:
    comment: Set True to record CPI coherently-integrated complex range profiles to disk
    'false': 'False'
    gui_hint: 1,4,1,1
    label: Record Enable
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: Placeholder for file_sink init (/dev/null); real path allocated on Record Enable as range_profiles_001, _002, ...
    value: '"/dev/null"'
  states: {}
- name: record_max_frames
  id: variable
  parameters:
    comment: Max CPI range-profile frames per Record Enable session; auto-stop when reached
    value: '100'
  states: {}
- name: record_output_dir
  id: variable
  parameters:
    comment: Directory for numbered CPI range-profile recordings (auto-created under repo data/)
    value: repo_data_dir("data", "experiment", "monostatic")
  states: {}
- name: record_output_index
  id: variable
  parameters:
    comment: Selector output; 0=file_sink, 1=null_sink
    value: 0 if record_enable else 1
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(fft_len * subcarrier_spacing)
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: int(fft_len * subcarrier_spacing)
  states: {}
- name: subcarrier_spacing
  id: variable
  parameters:
    value: 120e3
  states: {}
- name: transpose_len
  id: variable
  parameters:
    comment: CPI OFDM symbols per burst; 4 avoids qpsk>8192 sched limit at fft_len=2048
    value: '4'
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: zeropadding_fac
  id: variable
  parameters:
    value: '2'
  states: {}
- name: address
  id: parameter
  parameters:
    comment: USRP 349B642; QSFP 10.2; external 10MHz+PPS
    label: address (349B642)
    type: str
    value: '"type=x4xx,serial=33ABFDE,mgmt_addr=192.168.1.101,addr=192.168.11.2,clock_source=external,time_source=external"'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Record CPI coherently-integrated complex range profiles
    file: record_file_path
    type: complex
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: factor
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    type: complex
  states: {}
- name: blocks_null_sink_rec_0
  id: blocks_null_sink
  parameters:
    comment: Discard complex range profile stream when recording disabled
    type: complex
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: Route CPI complex range profile to file sink or null sink
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: record_output_index
    showports: 'False'
    type: complex
    vlen: fft_len*zeropadding_fac
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    minoutbuf: int(2*transpose_len*(fft_len+fft_len/4))
    tagname: length_tag_key
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    minoutbuf: 2*transpose_len
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    minoutbuf: 2*transpose_len
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: import_mics_test_record_flow_0
  id: import
  parameters:
    comment: mics_test record limit + auto-stop hooks (installed via snippet)
    imports: |-
      from isac_imp.mics_test_record_flow import install_mics_test_record_flow
      from isac_imp.record_paths import repo_data_dir
  states: {}
- name: ofdm_range_profile
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.ofdm_range_profile import OfdmRangeProfileBlock

      blk = OfdmRangeProfileBlock
    comment: Replaces divide + range FFT + mag + integrate + nlog10; out1 complex CPI for MUSIC
    fft_len: fft_len
    transpose_len: transpose_len
    zeropadding_fac: zeropadding_fac
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft_len
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: fft_len + fft_len//4
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: radar_ofdm_cyclic_prefix_remover_cvc_0
  id: radar_ofdm_cyclic_prefix_remover_cvc
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    len_key: '"packet_len"'
    minoutbuf: 2*transpose_len
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    antenna_rx: '''RX1'''
    antenna_tx: '''TX/RX'''
    args_rx: address
    args_tx: address
    center_freq: freq
    channel_rx: '0'
    channel_tx: '0'
    clock_source_rx: '''external'''
    clock_source_tx: '''external'''
    comment: external 10MHz REF IN + PPS IN; must match device args
    gain_rx: RX_gain
    gain_tx: TX_gain
    minoutbuf: min_out_buf_val
    num_delay_samps: int(num_delay_samp)
    samp_rate: int(samp_rate)
    time_source_rx: '''external'''
    time_source_tx: '''external'''
    timeout_rx: '0.2'
    timeout_tx: '0.2'
    wait_rx: wait_to_start
    wait_tx: wait_to_start
  states: {}
- name: range_music_block
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.range_music_block import RangeMusicBlock

      blk = RangeMusicBlock
    comment: 1D range MUSIC on CPI complex range profile (num_sources fixed at 1); annotates RangeProfilePlotBlock
    music_enable: music_enable
    num_sources: '1'
    range_bin_step: range_bin_step
    range_roi: range_roi
    subarray_size: '16'
    threshold: '0.1'
    vlen_in: fft_len*zeropadding_fac
  states: {}
- name: range_profile_plot
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.range_profile_plot import RangeProfilePlotBlock

      blk = RangeProfilePlotBlock
    comment: PyQtGraph range profile display (ROI slice + autoscale Y); standalone window
    range_bin_step: range_bin_step
    range_roi: range_roi
    vlen_in: fft_len*zeropadding_fac
  states: {}
- name: range_profile_record_limiter
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.range_profile_record_limiter import RangeProfileRecordLimiter

      blk = RangeProfileRecordLimiter
    comment: Passthrough CPI vectors; stop recording after record_max_frames
    file_sink_attr: '"blocks_file_sink_0"'
    record_base_name: ''
    record_enable: record_enable
    record_file_path_attr: '"record_file_path"'
    record_max_frames: int(record_max_frames)
    record_output_dir_override: None
    vlen_in: fft_len*zeropadding_fac
  states: {}
- name: sionna_resource_grid_tx
  id: epy_block
  parameters:
    _source_code: |
      from isac_imp.sionna_resource_grid_tx import SionnaResourceGridTxBlock

      blk = SionnaResourceGridTxBlock
    comment: Sionna ResourceGridMapper; replaces carrier_allocator
    cp_len: fft_len//4
    device: device
    fft_len: fft_len
    length_tag_key: length_tag_key
    minoutbuf: 4*transpose_len
    num_bits_per_symbol: '2'
    seed: '42'
    subcarrier_spacing: subcarrier_spacing
    transpose_len: transpose_len
  states: {}
- name: snippet_install_record_flow_0
  id: snippet
  parameters:
    code: install_mics_test_record_flow(self)
    comment: Bind record limit handler after top block init
    priority: '10'
    section: main_after_init
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', radar_usrp_echotimer_cc_0, '0']
- [blocks_selector_0, '0', blocks_file_sink_0, '0']
- [blocks_selector_0, '1', blocks_null_sink_rec_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_vxx_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', ofdm_range_profile, '1']
- [ofdm_range_profile, '0', range_profile_plot, '0']
- [ofdm_range_profile, '1', range_music_block, '0']
- [ofdm_range_profile, '1', range_profile_record_limiter, '0']
- [radar_ofdm_cyclic_prefix_remover_cvc_0, '0', fft_vxx_0_0, '0']
- [radar_usrp_echotimer_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [radar_usrp_echotimer_cc_0, '0', radar_ofdm_cyclic_prefix_remover_cvc_0, '0']
- [range_profile_record_limiter, '0', blocks_selector_0, '0']
- [sionna_resource_grid_tx, '0', fft_vxx_0, '0']
- [sionna_resource_grid_tx, '0', ofdm_range_profile, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
