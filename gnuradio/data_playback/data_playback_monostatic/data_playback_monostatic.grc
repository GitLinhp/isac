options:
  parameters:
    category: Custom
    description: Replay CPI complex range profiles recorded by data_collection_monostatic and display as dB range spectrum.
    generate_options: qt_gui
    hier_block_src_path: .:..
    id: data_playback_monostatic
    output_language: python
    title: Monostatic Range Profile Playback
  states: {}

blocks:
- name: R_max
  id: variable
  parameters:
    comment: 最大不模糊距离 (m)
    value: 3e8/2/samp_rate*fft_len
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: frame_rate_hz
  id: variable
  parameters:
    comment: CPI frame rate for replay throttle (must match data_collection_monostatic)
    value: samp_rate / (transpose_len * (fft_len + fft_len // 4))
  states: {}
- name: range_bin_step
  id: variable
  parameters:
    comment: 距离谱横轴步进 (m/bin)；GRC 显示 305.176m = 0.305 m
    value: 3e8/(2*int(fft_len*subcarrier_spacing)*zeropadding_fac)
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: Path to one monostatic CPI recording (e.g. range_profiles_001)
    value: repo_data_dir("data", "experiment", "monostatic") + "/range_profiles_001"
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(fft_len * subcarrier_spacing)
  states: {}
- name: subcarrier_spacing
  id: variable
  parameters:
    comment: Must match data_collection_monostatic (120 kHz)
    value: 120e3
  states: {}
- name: transpose_len
  id: variable
  parameters:
    value: '4'
  states: {}
- name: zeropadding_fac
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Complex CPI profile to linear power for dB display
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Read CPI coherently-integrated complex range profiles
    file: record_file_path
    repeat: 'True'
    type: complex
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: Linear power to dB for display (after |complex|^2)
    k: '0'
    n: '10'
    vlen: fft_len*zeropadding_fac
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Pace replay at CPI frame rate
    samples_per_second: frame_rate_hz
    type: complex
    vlen: fft_len*zeropadding_fac
  states: {}
- name: import_repo_data_dir_0
  id: import
  parameters:
    comment: Default monostatic recording directory under repo data/
    imports: from isac_imp.record_paths import repo_data_dir
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    comment: Replayed zero-Doppler range profile
    grid: 'True'
    label1: Range Profile
    name: '"Monostatic Range Profile Playback"'
    vlen: fft_len*zeropadding_fac
    x_axis_label: '"Range"'
    x_start: '0'
    x_step: range_bin_step
    x_units: '"m"'
    y_axis_label: '"Power (dB)"'
    y_units: '"dB"'
    ymax: '0'
    ymin: '-40'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
