options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: simulator_ofdm
    output_language: python
    run_command: '{python} -u run_simulator_ofdm.py'
  states: {}

blocks:
- name: idle_ms
  id: variable
  parameters:
    comment: Style 1 静默 (ms)；原 burst_pri_sec=0.1 → idle≈57 ms（CPI≈43 ms）
    value: max(0, int(1000*0.1 - 1000.0*ofdm_symbols*(fft_len+cp_len)/samp_rate))
  states: {}
- name: burst_mode
  id: variable
  parameters:
    comment: Style 1 burst 门控（Channel/Rx tag）
    value: idle_ms > 0
  states: {}
- name: time_lead_s
  id: variable
  parameters:
    comment: tx_time tag 提前量 [s]
    value: '0.05'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: 载频 (Hz)
    value: 6e9
  states: {}
- name: config_file
  id: variable
  parameters:
    comment: Sionna 发端 TOML 路径
    value: '"config/simulation/sensing/sensing_monostatic.toml"'
  states: {}
- name: cp_len
  id: variable
  parameters:
    comment: 循环前缀 (samples)，与 sensing_monostatic.toml num_cyclic_prefix 一致
    value: '512'
  states: {}
- name: fft_len
  id: variable
  parameters:
    comment: num_subcarriers
    value: '2048'
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: ofdm_symbols
  id: variable
  parameters:
    comment: num_symbols / 慢时间 FFT 长度
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: fft_len * subcarrier_spacing
    value: int(fft_len * subcarrier_spacing)
  states: {}
- name: subcarrier_spacing
  id: variable
  parameters:
    comment: 子载波间隔 (Hz)
    value: 15e3
  states: {}
- name: target_range
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: range
    start: '0.1'
    step: '1'
    stop: '10000'
    value: '100'
  states: {}
- name: target_velocity
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: Velocity
    start: '-150'
    step: '1'
    stop: '150'
    value: '5'
  states: {}
- name: tx_device
  id: variable
  parameters:
    comment: Sionna 计算设备
    value: '"cuda:0"'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: 暂代 OS-CFAR，消费 Sionna DD Rx out(0) complex[fft_len]
    type: complex
    vlen: fft_len
  states: {}
- name: import_0
  id: import
  parameters:
    imports: |-
      import numpy as np
      import sys
      import os
      from pathlib import Path
      _GRC_DIR = os.path.dirname(os.path.abspath(__file__)) if '__file__' in dir() else os.getcwd()
      _root = None
      for _h in (_GRC_DIR, os.getcwd()):
          _d = Path(_h).resolve()
          if _d.is_file():
              _d = _d.parent
          for _c in (_d, _d / 'gnuradio', *_d.parents):
              if (_c / 'bootstrap.py').is_file():
                  _root = str(_c)
                  break
          if _root:
              break
      if _root:
          if _root not in sys.path:
              sys.path.insert(0, _root)
          from bootstrap import setup_gnuradio_paths
          setup_gnuradio_paths()
      # 调参优先改 GRC 变量；Sionna 块内 merge_config(TOML, GRC) 覆盖同名字段
  states: {}
- name: radar_estimator_ofdm_0
  id: radar_estimator_ofdm
  parameters:
    axis_x: '[0, 10000]'
    axis_y: '[-150, 150]'
    comment: 轴标默认值；精确 R_max/v_max 由 Python merge_config 打印并刷新滑块
    len_x: fft_len
    len_y: ofdm_symbols
    merge_consecutive: 'True'
    symbol_x: '''range'''
    symbol_y: '''target_velocity'''
  states: {state: disabled}
- name: radar_os_cfar_2d_vc_0
  id: radar_os_cfar_2d_vc
  parameters:
    len_key: '"packet_len"'
    mult_threshold: '30'
    rel_threshold: '0.78'
    samp_compare: '[10,10]'
    samp_protect: '[0,0]'
    vlen: fft_len
  states: {state: disabled}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {state: disabled}
- name: sionna_dd_spectrogram_0
  id: sionna_dd_spectrogram
  parameters:
    autoscale_z: 'True'
    axis_x: '[0, 10000]'
    axis_y: '[-150, 150]'
    axis_z: '[-15,-12]'
    comment: 轴标默认值；每帧 packet_len 到达后事件刷新；R_max/v_max 由 merge_config 打印
    label: '''OFDM Radar'''
    len_key: '"packet_len"'
    vlen: fft_len
    xlabel: '''target_range'''
    ylabel: '''target_velocity'''
  states: {}
- name: sionna_static_target_0
  id: sionna_static_target
  parameters:
    azimuth: '0'
    burst_mode: burst_mode
    center_freq: center_freq
    comment: Torch static_target_simulator（替代 gr-radar static_target）
    cp_len: cp_len
    device: tx_device
    fft_len: fft_len
    length_tag_key: '"packet_len"'
    minoutbuf: int(2*ofdm_symbols)
    ofdm_symbols: ofdm_symbols
    position_rx: '0'
    range: target_range
    rcs: 1e25
    rndm_phaseshift: 'True'
    samp_rate: samp_rate
    self_coupling: 'True'
    self_coupling_db: '-10'
    velocity: target_velocity
  states: {}
- name: sionna_bootstrap_0
  id: sionna_bootstrap
  parameters:
    center_freq: center_freq
    comment: GPU 预热 + Python 感知性能打印（须先于 Sionna TX/RX 实例化）
    config_file: config_file
    cp_len: cp_len
    device: tx_device
    fft_len: fft_len
    ofdm_symbols: ofdm_symbols
    seed: '42'
    subcarrier_spacing: subcarrier_spacing
  states: {}
- name: sionna_dd_rx_0
  id: sionna_dd_rx
  parameters:
    burst_mode: burst_mode
    config_file: config_file
    center_freq: center_freq
    cp_len: cp_len
    device: tx_device
    fft_len: fft_len
    length_tag_key: length_tag_key
    log_eps: '1e-20'
    mininbuf: int(2*ofdm_symbols*(fft_len+max(cp_len, 1)))
    minoutbuf: int(2*ofdm_symbols)
    ofdm_symbols: ofdm_symbols
    seed: '42'
    subcarrier_spacing: subcarrier_spacing
  states: {}
- name: sionna_ofdm_tx_0
  id: sionna_ofdm_tx
  parameters:
    config_file: config_file
    center_freq: center_freq
    cp_len: cp_len
    device: tx_device
    fft_len: fft_len
    idle_ms: idle_ms
    length_tag_key: length_tag_key
    minoutbuf: int(2*ofdm_symbols*(fft_len+max(cp_len, 1)))
    ofdm_symbols: ofdm_symbols
    samp_rate: samp_rate
    seed: '42'
    subcarrier_spacing: subcarrier_spacing
    time_lead_s: time_lead_s
    uhd_burst_tags: 'True'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', sionna_dd_rx_0, '0']
- [radar_estimator_ofdm_0, Msg out, radar_print_results_0, Msg in]
- [radar_os_cfar_2d_vc_0, Msg out, radar_estimator_ofdm_0, Msg in]
- [sionna_static_target_0, '0', blocks_add_xx_0, '1']
- [sionna_static_target_0, '0', sionna_dd_rx_0, '0']
- [sionna_dd_rx_0, '0', blocks_null_sink_0, '0']
- [sionna_dd_rx_0, '1', sionna_dd_spectrogram_0, '0']
- [sionna_ofdm_tx_0, '0', sionna_static_target_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
