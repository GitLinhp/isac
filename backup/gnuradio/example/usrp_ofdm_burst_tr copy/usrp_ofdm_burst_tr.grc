options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: usrp_ofdm_burst_tr
    output_language: python
    title: USRP TX/RX (OFDM Burst)
  states: {}

blocks:
- name: RX_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: rx_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: TX_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: tx_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: config_file
  id: variable
  parameters:
    comment: TOML path (default sensing_monostatic; relative to repo config/)
    value: '"implementaion/ofdm_burst_source_large_sacle.toml"'
  states: {}
- name: dd_vlen
  id: variable
  parameters:
    comment: DD spectrogram / RX row vlen from TOML ROI
    value: resolve_dd_output_vlen(config_file, device, 42)
  states: {}
- name: device
  id: variable
  parameters:
    value: '"cuda:0"'
  states: {}
- name: freq_trig_level
  id: variable_qtgui_range
  parameters:
    comment: Freq Sink trigger level (dB, post-FFT PSD)
    gui_hint: 1,2,1,1
    label: freq_trig_level
    start: '-120'
    step: '5'
    stop: '0'
    value: '-90'
  states: {}
- name: gui_update_time_ms
  id: variable
  parameters:
    value: '10'
  states: {}
- name: idle_ms
  id: variable
  parameters:
    value: '400'
  states: {}
- name: ofdm_burst_samples
  id: variable
  parameters:
    comment: from TOML [ofdm] via resolve_ofdm_burst_len
    value: resolve_ofdm_burst_len(config_file, device, 42)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: from TOML [ofdm] via resolve_ofdm_samp_rate
    value: resolve_ofdm_samp_rate(config_file, device, 42)
  states: {}
- name: startup_delay_s
  id: variable
  parameters:
    comment: Delay before first burst after flowgraph start (s)
    value: '1.0'
  states: {}
- name: time_lead_s
  id: variable
  parameters:
    comment: tx_time lead ahead of wall clock (s)
    value: '0.5'
  states: {}
- name: time_mag_trig_level
  id: variable_qtgui_range
  parameters:
    comment: Time |IQ| Sink trigger level (linear envelope)
    gui_hint: 1,0,1,1
    label: time_mag_trig_level
    start: '0'
    step: '0.005'
    stop: '0.5'
    value: '5e-3'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    comment: OFDM burst amplitude scale (before USRP)
    gui_hint: 0,2,1,1
    label: tx_amp
    start: '0'
    step: '0.01'
    stop: '100'
    value: '30'
  states: {}
- name: address
  id: parameter
  parameters:
    label: UHD dev args
    type: str
    value: '"type=x4xx,mgmt_addr=192.168.1.100,addr=192.168.10.2"'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: RX envelope for burst trigger / time display
  states: {state: disabled}
- name: blocks_complex_to_mag_tx
  id: blocks_complex_to_mag
  parameters:
    comment: TX envelope before USRP (digital clip check)
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: ''
    name: '""'
    type: complex
  states: {state: disabled}
- name: freq
  id: parameter
  parameters:
    label: Default Frequency
    short_id: f
    type: eng_float
    value: 6.0e9
  states: {}
- name: import_isac_gr_setup
  id: import
  parameters:
    comment: resolve_dd_output_vlen for dd_vlen / spectrogram
    imports: from isac_imp.gr_setup import (resolve_dd_output_vlen, resolve_ofdm_samp_rate, resolve_ofdm_burst_len)
  states: {}
- name: ofdm_burst_sensing_rx
  id: epy_block
  parameters:
    _source_code: |
      """
      GNU Radio 嵌入式 Python 块：OFDM 突发感知接收（固定长度切包 + LS/DD）

      从 USRP RX 连续 IQ 流中，攒满 burst_len 后直接切包解调：
        y_rg = demodulator(y_time)
        h_freq = ls_channel_estimator(x_rg, y_rg)   # x_rg 来自离线 x_rg.npy
        h_dd = delay_doppler_spectrum(h_freq, sens_mode="monostatic")

      输出：log10(|h_dd|²) 按多普勒行输出的 float32 向量流，首行打 packet_len tag，
      供 SionnaDDSpectrogramPlot 显示。不打印距离/速度/RMSE。

      System / burst_len / OFDM 几何一律来自 TOML（config_file），不做 GRC OFDM 覆盖。
      不做相关同步；x_rg 从 source.cache_file 目录的 x_rg.npy 加载。
      corr_threshold / template_len 形参保留以兼容旧 GRC，内部忽略。
      """

      from __future__ import annotations

      import sys
      import time
      import traceback
      from collections import deque
      from typing import Any

      import numpy as np
      import pmt
      import torch
      from gnuradio import gr

      from isac.system import System
      from isac_imp.constants import TPP_DONT
      from isac_imp.gr_setup import (
          create_system,
          make_cache_key,
          resolve_dd_output_vlen,
          resolve_ofdm_burst_len,
      )

      _DEFAULT_CONFIG = "simulation/sensing/sensing_monostatic.toml"
      _TAG_PACKET_LEN = pmt.intern("packet_len")
      _LOG_EPS = 1e-20
      _LOG_PREFIX = "[OFDM Burst Sensing RX]"
      _FORECAST_MAX = 16384  # 调度器单次输入上限；整帧靠内部 _buf 攒齐


      def _dd_log_magnitude(h_dd: np.ndarray, log_eps: float = _LOG_EPS) -> np.ndarray:
          """|·|² → +ε → log10，形状保持 (n_doppler, n_delay)。"""
          mag2 = np.abs(h_dd.astype(np.complex128, copy=False)) ** 2
          return np.log10(mag2 + float(log_eps)).astype(np.float32)


      def _as_bool(value) -> bool:
          if isinstance(value, str):
              return value.strip().lower() in ("1", "true", "yes", "on")
          return bool(value)


      class blk(gr.basic_block):
          """
          固定长度切包 OFDM 感知接收：攒满 burst_len 后解调、LS/DD，并输出 DD log 谱行。
          """

          def __init__(
              self,
              config_file=_DEFAULT_CONFIG,
              device="cpu",
              seed=42,
              corr_threshold=0.3,
              template_len=0,
              idle_ms=400.0,
              dd_vlen=0,
              debug=False,
          ):
              """
              参数:
                  - config_file / device / seed: TOML 路径与计算设备；OFDM 几何来自 TOML
                  - corr_threshold / template_len: 兼容 GRC，已忽略（无相关同步）
                  - idle_ms: 切包处理后抑制期 (ms)，避免同一突发重复解调
                  - dd_vlen: 输出向量长度；<=0 时按 TOML ROI 时延列数自动解析
                  - debug: 是否向 stderr 打印切包/LS-DD 调试信息
              """
              self._config_file = str(config_file)
              self._device = str(device)
              self._seed = int(seed)
              self._corr_threshold = float(corr_threshold)  # unused; GRC compat
              self._template_len = int(template_len)  # unused; GRC compat
              self._idle_ms = float(idle_ms)
              self._debug = _as_bool(debug)
              self._burst_len = int(
                  resolve_ofdm_burst_len(self._config_file, self._device, self._seed)
              )
              if int(dd_vlen) > 0:
                  self._dd_vlen = int(dd_vlen)
              else:
                  self._dd_vlen = resolve_dd_output_vlen(
                      self._config_file,
                      self._device,
                      self._seed,
                  )

              gr.basic_block.__init__(
                  self,
                  name="OFDM Burst Sensing RX",
                  in_sig=[np.complex64],
                  out_sig=[(np.float32, self._dd_vlen)],
              )

              self._system: System | None = None
              self._x_rg: Any = None

              self._buf = np.zeros(0, dtype=np.complex64)
              self._suppress_until = 0.0
              self._processed_bursts = 0

              # 待输出的 DD 行：每项 (row_f32[vlen], is_first_row, n_rows)
              self._pending_rows: deque[tuple[np.ndarray, bool, int]] = deque()

              self._last_waiting_cache_log_at = 0.0
              self._logged_first_produce = False

              self.set_tag_propagation_policy(TPP_DONT)
              self._log(
                  f"init dd_vlen={self._dd_vlen} burst_len={self._burst_len} "
                  f"idle_ms={self._idle_ms} debug={self._debug} (config-only, no OFDM override)"
              )

          def _log(self, msg: str) -> None:
              if not self._debug:
                  return
              print(f"{_LOG_PREFIX} {msg}", file=sys.stderr, flush=True)

          @property
          def burst_len(self) -> int:
              return self._burst_len

          @property
          def dd_vlen(self) -> int:
              return self._dd_vlen

          def _cache_key(self) -> tuple:
              return make_cache_key(
                  self._config_file,
                  self._device,
                  self._seed,
                  None,
              )

          def _ensure_system(self) -> System:
              if self._system is None:
                  torch.set_num_threads(1)
                  cache_key = self._cache_key()
                  self._system = create_system(
                      self._config_file,
                      device=self._device,
                      seed=self._seed,
                      ofdm_overrides=None,
                  )
                  ofdm = self._system.params.ofdm
                  if ofdm is not None:
                      self._burst_len = int(
                          ofdm.num_symbols * (ofdm.fft_size + ofdm.cyclic_prefix_length)
                      )
                  self._log(
                      f"create_system config={self._config_file!r} device={self._device!r} "
                      f"key={cache_key} system_id={id(self._system)} burst_len={self._burst_len}"
                  )
              return self._system

          def _ensure_waveform(self) -> bool:
              """仅从缓存目录加载 x_rg.npy；成功返回 True。"""
              if self._x_rg is not None:
                  return True
              system = self._ensure_system()
              try:
                  self._x_rg = system.load_transmit_x_rg()
              except (FileNotFoundError, ValueError) as exc:
                  now = time.monotonic()
                  if now - self._last_waiting_cache_log_at >= 1.0:
                      self._last_waiting_cache_log_at = now
                      self._log(f"waiting for transmit x_rg.npy: {exc}")
                  return False
              self._log(f"load_transmit_x_rg ok x_rg={tuple(self._x_rg.shape)}")
              return True

          def _invalidate(self) -> None:
              self._system = None
              self._x_rg = None
              self._buf = np.zeros(0, dtype=np.complex64)
              self._pending_rows.clear()
              self._burst_len = int(
                  resolve_ofdm_burst_len(self._config_file, self._device, self._seed)
              )

          # --- GRC 可调属性 ---
          @property
          def config_file(self):
              return self._config_file

          @config_file.setter
          def config_file(self, value):
              self._config_file = str(value)
              self._invalidate()

          @property
          def device(self):
              return self._device

          @device.setter
          def device(self, value):
              self._device = str(value)
              self._invalidate()

          @property
          def seed(self):
              return self._seed

          @seed.setter
          def seed(self, value):
              self._seed = int(value)
              self._invalidate()

          @property
          def corr_threshold(self):
              return self._corr_threshold

          @corr_threshold.setter
          def corr_threshold(self, value):
              self._corr_threshold = float(value)

          @property
          def template_len(self):
              return self._template_len

          @template_len.setter
          def template_len(self, value):
              self._template_len = int(value)

          @property
          def idle_ms(self):
              return self._idle_ms

          @idle_ms.setter
          def idle_ms(self, value):
              self._idle_ms = float(value)

          @property
          def debug(self):
              return self._debug

          @debug.setter
          def debug(self, value):
              self._debug = _as_bool(value)

          def forecast(self, noutput_items, ninputs):
              del noutput_items
              need = min(self.burst_len, _FORECAST_MAX)
              need = max(need, 4096)
              return [need] * ninputs

          def _queue_dd_frame(self, h_dd: torch.Tensor) -> tuple[int, float, float]:
              """将 h_dd 转为 log 幅度行并入队；返回 (n_rows, finite_min, finite_max)。"""
              arr = h_dd.detach().cpu().numpy()
              while arr.ndim > 2:
                  arr = arr[0]
              log_mag = _dd_log_magnitude(arr)
              n_rows, n_cols = int(log_mag.shape[0]), int(log_mag.shape[1])
              vlen = self._dd_vlen
              for i in range(n_rows):
                  row = np.full(vlen, np.nan, dtype=np.float32)
                  n = min(n_cols, vlen)
                  row[:n] = log_mag[i, :n]
                  self._pending_rows.append((row, i == 0, n_rows))

              finite = log_mag[np.isfinite(log_mag)]
              if finite.size:
                  return n_rows, float(finite.min()), float(finite.max())
              return n_rows, float("nan"), float("nan")

          def _process_burst(self, y_np: np.ndarray) -> None:
              if y_np.size < self.burst_len:
                  self._log(f"burst too short: size={y_np.size} need={self.burst_len}")
                  return
              y_np = y_np[: self.burst_len]

              system = self._ensure_system()
              if not self._ensure_waveform():
                  self._log("skip sensing: transmit x_rg.npy not loaded")
                  return
              x_rg = self._x_rg

              comps = system.components
              if comps.demodulator is None:
                  self._log("skip sensing: demodulator is None")
                  return

              y_time = torch.from_numpy(np.ascontiguousarray(y_np)).to(
                  device=system.device,
                  dtype=torch.complex64,
              )
              while y_time.dim() < 3:
                  y_time = y_time.unsqueeze(0)

              with torch.inference_mode():
                  y_rg = comps.demodulator(y_time)
                  h_freq = comps.ls_channel_estimator(x_rg, y_rg)
                  h_dd = comps.delay_doppler_spectrum(h_freq, sens_mode="monostatic")
                  n_rows, lo, hi = self._queue_dd_frame(h_dd)

              self._processed_bursts += 1
              self._log(
                  f"sensing ok #{self._processed_bursts} h_dd={tuple(h_dd.shape)} "
                  f"rows={n_rows} log10_min={lo:.3f} log10_max={hi:.3f} "
                  f"pending={len(self._pending_rows)}"
              )

          def _try_slice_and_process(self) -> None:
              """攒满 burst_len 后切包解调；idle 抑制期内只裁剪缓冲。"""
              burst_len = self.burst_len
              suppress = time.monotonic() < self._suppress_until

              max_buf = burst_len * 2
              if self._buf.size > max_buf:
                  self._buf = self._buf[-max_buf:]

              if suppress:
                  return

              if self._buf.size < burst_len:
                  return

              y_burst = self._buf[:burst_len].copy()
              self._buf = self._buf[burst_len:]
              self._suppress_until = time.monotonic() + max(0.0, self._idle_ms / 1000.0)

              self._log(f"slice packet burst_len={burst_len} remain_buf={self._buf.size}")
              try:
                  self._process_burst(y_burst)
              except Exception:
                  self._log("sensing failed:")
                  traceback.print_exc(file=sys.stderr)

          def _produce_pending(self, out: np.ndarray) -> int:
              """写出待发送 DD 行，返回写出行数。"""
              n_out = len(out)
              produced = 0
              while produced < n_out and self._pending_rows:
                  row, is_first, n_rows = self._pending_rows.popleft()
                  if is_first:
                      abs_out = self.nitems_written(0) + produced
                      self.add_item_tag(
                          0, abs_out, _TAG_PACKET_LEN, pmt.from_long(int(n_rows))
                      )
                      if not self._logged_first_produce:
                          self._logged_first_produce = True
                          self._log(
                              f"produce first frame packet_len={n_rows} vlen={self._dd_vlen}"
                          )
                  out[produced][:] = row
                  produced += 1
              return produced

          def general_work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_in = len(inp)

              if n_in > 0:
                  if not self._ensure_waveform():
                      self.consume(0, n_in)
                  else:
                      self._buf = np.concatenate(
                          (self._buf, np.asarray(inp, dtype=np.complex64))
                      )
                      self.consume(0, n_in)
                      self._try_slice_and_process()

              return self._produce_pending(out)
    comment: Config-only RX → LS/DD → log|h_dd|^2 rows
    config_file: config_file
    corr_threshold: '0.3'
    dd_vlen: dd_vlen
    debug: 'False'
    device: device
    idle_ms: idle_ms
    seed: '42'
    template_len: '0'
  states: {}
- name: ofdm_burst_source
  id: epy_block
  parameters:
    _source_code: |
      """
      GNU Radio 嵌入式 Python 块：OFDM 突发源（纯 x_time.npy 时域重放）

      周期性输出 OFDM 时域突发，并在流上附加 UHD 所需的 stream tag：
        tx_sob  — 突发开始（Start Of Burst）
        tx_time — 计划发射时刻（绝对 Unix 时间，秒 + 小数部分）
        tx_eob  — 突发结束（End Of Burst）

      Style 1 约定：下游 USRP Sink 的 len_tag_name 必须留空，由 tag 而非包长 tag 界定突发边界。

      发射链：由 config_file 解析 source.cache_file（缓存目录）与 OFDM samp_rate，
      再仅 np.load 目录内 x_time.npy → 乘 tx_amp 后周期性重放。
      不构建 System 调制链，不调用 create_system / transmit()。System 仅由接收端构建。

      注意：__init__ 形参默认值须与 GRC 变量保持同步。
      """

      from __future__ import annotations

      import sys
      import time
      from pathlib import Path

      import numpy as np
      import pmt
      from gnuradio import gr

      from isac import PROJECT_ROOT
      from isac_imp.constants import TAG_EOB, TAG_SOB, TAG_TIME, TPP_DONT, make_tx_time_pmt
      from isac_imp.gr_setup import resolve_ofdm_samp_rate, resolve_source_cache_file

      _DEFAULT_CONFIG = "simulation/sensing/sensing_monostatic.toml"
      _RESOLVE_DEVICE = "cpu"
      _RESOLVE_SEED = 42
      _LOG_PREFIX = "[OFDM Burst Source]"


      class blk(gr.basic_block):
          """
          Style 1 OFDM 突发源：启动时按 TOML 加载 x_time.npy，之后周期性重放并打 UHD 定时 tag。

          工作流程：突发期内从缓存输出样本并打 tag；突发结束后进入 idle 静默期，
          静默期不产出样本（general_work 返回 0），到期再启动下一突发。
          """

          def __init__(
              self,
              config_file=_DEFAULT_CONFIG,
              idle_ms=900.0,
              tx_amp=0.3,
              time_lead_s=0.3,
              startup_delay_s=0.2,
          ):
              """
              参数:
                  - config_file:      TOML 路径；从中解析 source.cache_file（目录）与 OFDM samp_rate
                  - idle_ms:          两次突发之间的纯静默间隔 (毫秒)，不含突发本身时长
                  - tx_amp:           输出幅度缩放，建议 ≤ 1.0 以免 USRP 饱和
                  - time_lead_s:      tx_time 相对当前 wall-clock 的提前量 (秒)
                  - startup_delay_s:  首突发启动前的初始等待 (秒)
              """
              gr.basic_block.__init__(
                  self,
                  name="OFDM Burst Source",
                  in_sig=[],
                  out_sig=[np.complex64],
              )
              self._config_file = str(config_file)
              self._cache_dir, self._samp_rate = self._resolve_from_config(self._config_file)
              self._idle_ms = float(idle_ms)
              self._tx_amp = float(tx_amp)
              self._time_lead_s = float(time_lead_s)
              self._startup_delay_s = float(startup_delay_s)

              self._burst_active = False
              self._burst_idx = 0
              self._next_burst_at = time.monotonic() + self._startup_delay_s

              self._burst_buffer: np.ndarray | None = None
              self._burst_len = 0
              self._idle_s = max(0.0, self._idle_ms / 1000.0)

              self.set_tag_propagation_policy(TPP_DONT)
              self.set_min_output_buffer(4096)

          @staticmethod
          def _resolve_from_config(config_file: str) -> tuple[str, float]:
              cache_dir = resolve_source_cache_file(
                  config_file, _RESOLVE_DEVICE, _RESOLVE_SEED
              )
              samp_rate = float(
                  resolve_ofdm_samp_rate(config_file, _RESOLVE_DEVICE, _RESOLVE_SEED)
              )
              return cache_dir, samp_rate

          def start(self):
              """流图启动时预热加载 x_time.npy，避免首包冷启动导致 Sink underflow。"""
              self._ensure_burst()
              self._next_burst_at = time.monotonic() + self._startup_delay_s
              return True

          def _log(self, msg: str) -> None:
              print(f"{_LOG_PREFIX} {msg}", file=sys.stderr, flush=True)

          def _resolve_cache_dir(self) -> Path:
              path = Path(self._cache_dir)
              if not path.is_absolute():
                  path = PROJECT_ROOT / path
              return path

          def _invalidate_burst(self) -> None:
              """GRC 参数变更时清空本地缓存，下次 general_work 触发重建。"""
              self._burst_buffer = None

          def _ensure_burst(self) -> np.ndarray:
              """懒加载入口：缓存未命中时 np.load，返回突发缓冲。"""
              if self._burst_buffer is None:
                  self._load_burst()
              assert self._burst_buffer is not None
              return self._burst_buffer

          def _load_burst(self) -> None:
              """仅从缓存目录读取 x_time.npy，乘 tx_amp 建突发缓冲。"""
              path = self._resolve_cache_dir() / "x_time.npy"
              if not path.is_file():
                  raise FileNotFoundError(
                      f"发射时域缓存不存在: {path}；请先离线运行 transmit() 生成"
                  )
              x_time = np.asarray(np.load(path))
              burst = x_time.squeeze().astype(np.complex64, copy=False)
              burst_buffer = (burst * self._tx_amp).astype(np.complex64, copy=False)
              self._burst_buffer = burst_buffer
              self._burst_len = int(burst_buffer.size)
              self._idle_s = max(0.0, self._idle_ms / 1000.0)
              self.set_min_output_buffer(max(4096, self._burst_len * 2))
              self._log(
                  f"load x_time.npy ok config={self._config_file!r} path={path} "
                  f"x_time={tuple(x_time.shape)} burst_len={self._burst_len} "
                  f"samp_rate={self._samp_rate}"
              )

          def _recompute_idle(self) -> None:
              """仅 idle_ms 变更时重算静默期，无需重建波形。"""
              self._idle_s = max(0.0, self._idle_ms / 1000.0)

          @property
          def config_file(self):
              return self._config_file

          @config_file.setter
          def config_file(self, value):
              self._config_file = str(value)
              self._cache_dir, self._samp_rate = self._resolve_from_config(self._config_file)
              self._invalidate_burst()

          @property
          def cache_file(self):
              """只读：由 config_file 解析得到的缓存目录路径。"""
              return self._cache_dir

          @property
          def samp_rate(self):
              """只读：由 config_file 解析得到的 OFDM 采样率。"""
              return self._samp_rate

          @property
          def burst_len(self):
              return self._burst_len

          @property
          def idle_ms(self):
              return self._idle_ms

          @idle_ms.setter
          def idle_ms(self, value):
              self._idle_ms = float(value)
              self._recompute_idle()

          @property
          def tx_amp(self):
              return self._tx_amp

          @tx_amp.setter
          def tx_amp(self, value):
              self._tx_amp = float(value)
              self._invalidate_burst()

          @property
          def time_lead_s(self):
              return self._time_lead_s

          @time_lead_s.setter
          def time_lead_s(self, value):
              self._time_lead_s = float(value)

          @property
          def startup_delay_s(self):
              return self._startup_delay_s

          @startup_delay_s.setter
          def startup_delay_s(self, value):
              self._startup_delay_s = float(value)

          def forecast(self, noutput_items, ninputs):
              """无输入端口，不向调度器声明输入需求。"""
              del noutput_items, ninputs
              return []

          def _schedule_delay_s(self) -> float:
              """
              计算当前突发结束后，到下一突发开始前的等待时间（秒）。

              周期 = max(idle + burst, burst)；返回值 = 周期 - burst，即纯 idle 时长。
              """
              if self._samp_rate <= 0:
                  return max(0.0, self._idle_s)
              burst_s = self._burst_len / self._samp_rate
              period_s = max(self._idle_s + burst_s, burst_s)
              return max(0.0, period_s - burst_s)

          def _tx_time_pmt(self):
              """
              构造 tx_time tag 的 PMT 值：(整数秒, 小数秒)。

              使用 time.time() + time_lead_s，与 UHD timed TX 的绝对时刻格式一致。
              """
              return make_tx_time_pmt(time.time() + self._time_lead_s)

          def general_work(self, input_items, output_items):
              """
              主工作函数：按块从缓存重放 OFDM 突发，在突发首尾附加 UHD tag。

              静默期内返回 0（不消耗输出缓冲）；突发可分多次 general_work 完成。
              返回值 n 表示本次写入输出端口的有效样本数。
              """
              del input_items
              burst_buffer = self._ensure_burst()
              out = output_items[0]

              if not self._burst_active:
                  if time.monotonic() < self._next_burst_at:
                      return 0
                  self._burst_active = True
                  self._burst_idx = 0

              n_remain = self._burst_len - self._burst_idx
              n = min(len(out), n_remain)
              if n <= 0:
                  return 0

              out[:n] = burst_buffer[self._burst_idx : self._burst_idx + n]

              abs_out = self.nitems_written(0)
              if self._burst_idx == 0:
                  self.add_item_tag(0, abs_out, TAG_SOB, pmt.PMT_T)
                  self.add_item_tag(0, abs_out, TAG_TIME, self._tx_time_pmt())

              self._burst_idx += n
              if self._burst_idx >= self._burst_len:
                  self.add_item_tag(0, abs_out + n - 1, TAG_EOB, pmt.PMT_T)
                  self._burst_active = False
                  self._next_burst_at = time.monotonic() + self._schedule_delay_s()

              return n
    comment: config_file → x_time.npy replay + UHD SOB/TIME/EOB
    config_file: config_file
    idle_ms: idle_ms
    startup_delay_s: startup_delay_s
    time_lead_s: time_lead_s
    tx_amp: tx_amp
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    comment: Burst-triggered spectrum (NORM, level=freq_trig_level)
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    label: RX Spectrum
    label1: RX
    name: RX Freq
    tr_level: freq_trig_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: gui_update_time_ms * 1e-3
    ymin: '-120'
  states: {state: disabled}
- name: qtgui_time_sink_tx
  id: qtgui_time_sink_x
  parameters:
    comment: TX digital clip check; flat top at 1.0 means saturation
    ctrlpanel: 'True'
    gui_hint: 2,0,1,3
    name: TX Time |IQ|
    size: int(ofdm_burst_samples)
    srate: samp_rate
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"tx_sob"'
    type: float
    update_time: gui_update_time_ms * 1e-3
    ylabel: '|IQ|'
    ymax: '1.0'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: 3,0,1,3
    name: RX Time |IQ|
    size: int(ofdm_burst_samples * 1.5)
    srate: samp_rate
    tr_level: time_mag_trig_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: gui_update_time_ms * 1e-3
    ylabel: '|IQ|'
    ymax: '0.5'
    ymin: '0'
  states: {state: disabled}
- name: sionna_dd_spectrogram_0
  id: sionna_dd_spectrogram
  parameters:
    autoscale_z: 'True'
    axis_x: '[0, 50]'
    axis_y: '[-10, 10]'
    axis_z: '[-15, -12]'
    comment: DD spectrogram GUI (range/velocity); vlen matches ROI delay bins (dd_vlen)
    label: '"DD Spectrogram"'
    len_key: '"packet_len"'
    vlen: dd_vlen
    xlabel: '"target_range"'
    ylabel: '"target_velocity"'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    clock_rate: '0'
    dev_addr: address
    dev_args: '""'
    gain0: TX_gain
    len_tag_name: ''
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    center_freq0: freq
    clock_rate: '0'
    dev_addr: address
    dev_args: '""'
    gain0: RX_gain
    minoutbuf: '262144'
    samp_rate: samp_rate
    stream_args: num_recv_frames=512,recv_buff_size=25000000
    stream_chans: '[2]'
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_tx, '0', qtgui_time_sink_tx, '0']
- [ofdm_burst_sensing_rx, '0', sionna_dd_spectrogram_0, '0']
- [ofdm_burst_source, '0', blocks_complex_to_mag_tx, '0']
- [ofdm_burst_source, '0', blocks_tag_debug_0, '0']
- [ofdm_burst_source, '0', uhd_usrp_sink_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_0_0, '0', ofdm_burst_sensing_rx, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
