options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: usrp_ofdm_burst_tr
    output_language: python
    title: USRP TX/RX (OFDM Burst)
  states: {}

blocks:
- name: RX_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: rx_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: TX_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: tx_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: burst_period_ms
  id: variable
  parameters:
    comment: message_strobe period for header_payload_demux frame_len
    value: idle_ms
  states: {}
- name: config_file
  id: variable
  parameters:
    comment: TOML path (default sensing_monostatic; relative to repo config/)
    value: '"implementaion/ofdm_burst_source_large_sacle.toml"'
  states: {}
- name: corr_threshold
  id: variable
  parameters:
    comment: ofdm_sync_sc_cfb correlation threshold
    value: '0.6'
  states: {}
- name: cp_len
  id: variable
  parameters:
    comment: from TOML [ofdm]
    value: resolve_ofdm_fft_cp(config_file)[1]
  states: {}
- name: dd_vlen
  id: variable
  parameters:
    comment: DD spectrogram / RX row vlen from TOML ROI
    value: resolve_dd_output_vlen(config_file)
  states: {}
- name: device
  id: variable
  parameters:
    value: '"cuda:0"'
  states: {}
- name: fft_len
  id: variable
  parameters:
    comment: from TOML [ofdm]
    value: resolve_ofdm_fft_cp(config_file)[0]
  states: {}
- name: frame_len_tag
  id: variable
  parameters:
    comment: header_payload_demux length tag key
    value: '"frame_len"'
  states: {}
- name: freq_trig_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: freq_trig_level
    start: '-120'
    step: '5'
    stop: '0'
    value: '-90'
  states: {}
- name: gui_update_time_ms
  id: variable
  parameters:
    value: '10'
  states: {}
- name: hdr_ack_msg
  id: variable
  parameters:
    comment: frame_len message for header_payload_demux
    value: pmt.dict_add(pmt.make_dict(), pmt.intern("frame_len"), pmt.from_long(resolve_ofdm_num_symbols(config_file)))
  states: {}
- name: header_len
  id: variable
  parameters:
    comment: SC sync1+sync2 OFDM symbols (no comm header)
    value: '2'
  states: {}
- name: idle_ms
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: n_carriers
  id: variable
  parameters:
    comment: occupied subcarriers count (fft-2)
    value: fft_len - 2
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    comment: GR sync word carrier set
    value: (tuple(range(-n_carriers//2, 0)) + tuple(range(1, n_carriers//2+1)),)
  states: {}
- name: ofdm_burst_samples
  id: variable
  parameters:
    comment: from TOML [ofdm] via resolve_ofdm_burst_len
    value: resolve_ofdm_burst_len(config_file)
  states: {}
- name: payload_syms
  id: variable
  parameters:
    comment: from TOML [ofdm] num_symbols
    value: resolve_ofdm_num_symbols(config_file)
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    comment: pilot tones outside occupied band
    value: (tuple(range(-n_carriers//2-2, -n_carriers//2)) + tuple(range(n_carriers//2+1, n_carriers//2+3)),)
  states: {}
- name: rx_sync_min_buf
  id: variable
  parameters:
    comment: min buffer for GR SC sync chain only (not full payload)
    value: max(65536, int((header_len + 8) * (fft_len + cp_len)))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: from TOML [ofdm] via resolve_ofdm_samp_rate
    value: resolve_ofdm_samp_rate(config_file)
  states: {}
- name: startup_delay_s
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    comment: GR Schmidl-Cox sync word 1
    value: list(digital.ofdm_txrx._make_sync_word1(fft_len, occupied_carriers, pilot_carriers))
  states: {}
- name: sync_word2
  id: variable
  parameters:
    comment: GR Schmidl-Cox sync word 2
    value: list(digital.ofdm_txrx._make_sync_word2(fft_len, occupied_carriers, pilot_carriers))
  states: {}
- name: time_lead_s
  id: variable
  parameters:
    comment: 'deprecated: no longer used (SOB-only TX)'
    value: '0.5'
  states: {}
- name: time_mag_trig_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: time_mag_trig_level
    start: '0'
    step: '0.005'
    stop: '0.5'
    value: '5e-3'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    comment: OFDM burst amplitude scale (before USRP)
    gui_hint: 0,2,1,1
    label: tx_amp
    start: '0'
    step: '0.01'
    stop: '100'
    value: '30'
  states: {}
- name: address
  id: parameter
  parameters:
    label: UHD dev args
    type: str
    value: '"type=x4xx,mgmt_addr=192.168.1.100,addr=192.168.10.2"'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: CFO correction from ofdm_sync_sc_cfb
    minoutbuf: rx_sync_min_buf
    sensitivity: (-2.0/fft_len)
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: RX envelope for burst trigger / time display
  states: {state: disabled}
- name: blocks_complex_to_mag_tx
  id: blocks_complex_to_mag
  parameters:
    comment: TX envelope before USRP (digital clip check)
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: delayed IQ for CFO multiply
    delay: (fft_len+cp_len)
    minoutbuf: rx_sync_min_buf
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: periodic frame_len for header_payload_demux
    msg: hdr_ack_msg
    period: '1000'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: apply CFO correction
    minoutbuf: rx_sync_min_buf
    type: complex
  states: {}
- name: blocks_null_sink_hdr
  id: blocks_null_sink
  parameters:
    comment: discard SC header symbols
    type: complex
    vlen: fft_len
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: ''
    name: '""'
    type: complex
  states: {state: disabled}
- name: dd_spectrum_plot_0
  id: dd_spectrum_plot
  parameters:
    autoscale_z: 'True'
    axis_x: '[0, 50]'
    axis_y: '[-10, 10]'
    axis_z: '[-15, -12]'
    comment: DD spectrogram GUI (range/velocity); vlen matches ROI delay bins (dd_vlen)
    label: '"DD Spectrogram"'
    len_key: '"packet_len"'
    vlen: dd_vlen
    xlabel: '"target_range"'
    ylabel: '"target_velocity"'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    comment: 2 sync symbols then payload (scalar stream for Sionna demod)
    guard_interval: cp_len
    header_len: header_len
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: frame_len_tag
    minoutbuf: rx_sync_min_buf
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '""'
    type: complex
  states: {}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    comment: Schmidl-Cox sync (rx_ofdm style)
    cp_len: cp_len
    fft_len: fft_len
    minoutbuf: rx_sync_min_buf
    threshold: corr_threshold
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Default Frequency
    short_id: f
    type: eng_float
    value: 6.0e9
  states: {}
- name: import_isac_gr_setup
  id: import
  parameters:
    comment: resolve_* for GRC variables; digital/analog for SC sync chain
    imports: from gnuradio import digital, analog; import pmt; from isac_imp.gr_setup import (resolve_dd_output_vlen, resolve_ofdm_samp_rate, resolve_ofdm_burst_len, resolve_ofdm_fft_cp, resolve_ofdm_num_symbols, resolve_gr_carrier_tuples)
  states: {}
- name: ofdm_burst_sensing_rx
  id: epy_block
  parameters:
    _source_code: |
      """
      GNU Radio 嵌入式 Python 块：OFDM 突发感知接收（GR 同步后 LS/DD）

      上游 ``header_payload_demux`` 在 SC 同步 + CFO 补偿后按 OFDM 符号向量（vlen=fft_len）
      输出载荷；本块按符号计数攒齐 ``burst_len`` 样点后异步执行 LS/DD。

      System / burst_len / OFDM 几何一律来自 TOML（config_file）。
      注意：__init__ 形参默认值须与 GRC 变量保持同步。
      """

      from __future__ import annotations

      import queue
      import sys
      import traceback
      from collections import deque
      from concurrent.futures import ThreadPoolExecutor
      from typing import Any

      import numpy as np
      import pmt
      import torch
      from gnuradio import gr

      from isac.system import System
      from isac.utils import set_random_seed
      from isac_imp.burst_pack import TPP_DONT
      from isac_imp.gr_setup import (
          resolve_dd_output_vlen,
          resolve_ofdm_burst_len,
          resolve_ofdm_fft_cp,
          resolve_ofdm_num_symbols,
      )

      # ---------------------------------------------------------------------------
      # 模块常量
      # ---------------------------------------------------------------------------

      _DEFAULT_CONFIG = "simulation/sensing/sensing_monostatic.toml"
      _TAG_PACKET_LEN = pmt.intern("packet_len")
      _TAG_FRAME_LEN = pmt.intern("frame_len")
      _LOG_EPS = 1e-20
      _LOG_PREFIX = "[OFDM Burst Sensing RX]"


      def _dd_log_magnitude(h_dd: np.ndarray, log_eps: float = _LOG_EPS) -> np.ndarray:
          """|·|² → +ε → log10，形状保持 (n_doppler, n_delay)。"""
          mag2 = np.abs(h_dd.astype(np.complex128, copy=False)) ** 2
          return np.log10(mag2 + float(log_eps)).astype(np.float32)


      class blk(gr.sync_block):
          """GR 同步后按 OFDM 符号向量计数攒包的感知接收。"""

          def __init__(
              self,
              config_file=_DEFAULT_CONFIG,
              device="cpu",
              seed=42,
          ):
              self._config_file = str(config_file)
              self._device = str(device)
              self._seed = int(seed)
              self._fft_size, self._cp_len = resolve_ofdm_fft_cp(self._config_file)
              self._payload_syms = int(resolve_ofdm_num_symbols(self._config_file))
              self._burst_len = int(resolve_ofdm_burst_len(self._config_file))
              self._dd_vlen = resolve_dd_output_vlen(self._config_file)

              gr.sync_block.__init__(
                  self,
                  name="OFDM Burst Sensing RX",
                  in_sig=[(np.complex64, self._fft_size)],
                  out_sig=[(np.float32, self._dd_vlen)],
              )

              self._system: System | None = None
              self._x_rg: Any = None

              self._sym_buf = np.zeros(
                  (self._payload_syms, self._fft_size), dtype=np.complex64
              )
              self._sym_idx = 0

              self._executor: ThreadPoolExecutor | None = None
              self._worker_busy = False
              self._result_queue: queue.Queue[
                  list[tuple[np.ndarray, bool, int]]
              ] = queue.Queue()
              self._pending_rows: deque[tuple[np.ndarray, bool, int]] = deque()

              self.set_tag_propagation_policy(TPP_DONT)
              self._apply_min_input_buffer()

          def _apply_min_input_buffer(self) -> None:
              if hasattr(self, "set_min_input_buffer"):
                  self.set_min_input_buffer(max(4096, self._payload_syms))

          @property
          def burst_len(self) -> int:
              return self._burst_len

          @property
          def dd_vlen(self) -> int:
              return self._dd_vlen

          def start(self):
              self._shutdown_worker()
              self._executor = ThreadPoolExecutor(
                  max_workers=1, thread_name_prefix="sensing_rx"
              )
              self._worker_busy = False
              self._sym_idx = 0
              return True

          def stop(self):
              self._shutdown_worker()
              return True

          def _shutdown_worker(self) -> None:
              if self._executor is not None:
                  self._executor.shutdown(wait=False, cancel_futures=True)
                  self._executor = None
              self._worker_busy = False
              while True:
                  try:
                      self._result_queue.get_nowait()
                  except queue.Empty:
                      break

          def _ensure_system(self) -> System:
              if self._system is None:
                  torch.set_num_threads(1)
                  set_random_seed(self._seed)
                  self._system = System(self._config_file, device=self._device)
                  ofdm = self._system.params.ofdm
                  if ofdm is not None:
                      self._fft_size = int(ofdm.fft_size)
                      self._cp_len = int(ofdm.cyclic_prefix_length)
                      self._payload_syms = int(ofdm.num_symbols)
                      self._burst_len = int(
                          ofdm.num_symbols * (ofdm.fft_size + ofdm.cyclic_prefix_length)
                      )
                      self._sym_buf = np.zeros(
                          (self._payload_syms, self._fft_size), dtype=np.complex64
                      )
                      self._apply_min_input_buffer()
              return self._system

          def _ensure_waveform(self) -> bool:
              if self._x_rg is not None:
                  return True
              system = self._ensure_system()
              cache = system.components.transmit_cache
              if cache is None:
                  return False
              try:
                  self._x_rg = cache.load_x_rg()
              except (FileNotFoundError, ValueError):
                  return False
              return True

          def _invalidate(self) -> None:
              self._shutdown_worker()
              self._system = None
              self._x_rg = None
              self._sym_idx = 0
              self._pending_rows.clear()
              self._fft_size, self._cp_len = resolve_ofdm_fft_cp(self._config_file)
              self._payload_syms = int(resolve_ofdm_num_symbols(self._config_file))
              self._burst_len = int(resolve_ofdm_burst_len(self._config_file))
              self._dd_vlen = resolve_dd_output_vlen(self._config_file)
              self._sym_buf = np.zeros(
                  (self._payload_syms, self._fft_size), dtype=np.complex64
              )
              self._apply_min_input_buffer()

          @property
          def config_file(self):
              return self._config_file

          @config_file.setter
          def config_file(self, value):
              self._config_file = str(value)
              self._invalidate()

          @property
          def device(self):
              return self._device

          @device.setter
          def device(self, value):
              self._device = str(value)
              self._invalidate()

          @property
          def seed(self):
              return self._seed

          @seed.setter
          def seed(self, value):
              self._seed = int(value)
              self._invalidate()

          def _rows_from_h_dd(self, h_dd: torch.Tensor) -> list[tuple[np.ndarray, bool, int]]:
              arr = h_dd.detach().cpu().numpy()
              while arr.ndim > 2:
                  arr = arr[0]
              log_mag = _dd_log_magnitude(arr)
              n_rows, n_cols = int(log_mag.shape[0]), int(log_mag.shape[1])
              vlen = self._dd_vlen
              rows: list[tuple[np.ndarray, bool, int]] = []
              for i in range(n_rows):
                  row = np.full(vlen, np.nan, dtype=np.float32)
                  n = min(n_cols, vlen)
                  row[:n] = log_mag[i, :n]
                  rows.append((row, i == 0, n_rows))
              return rows

          def _compute_burst_rows(
              self, y_np: np.ndarray
          ) -> list[tuple[np.ndarray, bool, int]]:
              burst_len = self._burst_len
              if y_np.size < burst_len:
                  return []
              y_np = y_np[:burst_len]

              system = self._ensure_system()
              if self._x_rg is None:
                  return []
              x_rg = self._x_rg

              comps = system.components
              if comps.demodulator is None:
                  return []

              y_time = torch.from_numpy(np.ascontiguousarray(y_np)).to(
                  device=system.device,
                  dtype=torch.complex64,
              )
              while y_time.dim() < 3:
                  y_time = y_time.unsqueeze(0)

              with torch.inference_mode():
                  y_rg = comps.demodulator(y_time)
                  h_freq = comps.ls_channel_estimator(x_rg, y_rg)
                  h_dd = comps.delay_doppler_spectrum(h_freq, sens_mode="monostatic")
                  return self._rows_from_h_dd(h_dd)

          def _on_burst_done(self, future) -> None:
              try:
                  rows = future.result()
                  if rows:
                      self._result_queue.put(rows)
              except Exception:
                  traceback.print_exc(file=sys.stderr)
              finally:
                  self._worker_busy = False

          def _submit_burst_async(self, y_burst: np.ndarray) -> None:
              if self._executor is None or self._worker_busy:
                  return
              self._worker_busy = True
              print(
                  f"{_LOG_PREFIX} payload_len={y_burst.size} (GR sync)",
                  file=sys.stderr,
                  flush=True,
              )
              fut = self._executor.submit(self._compute_burst_rows, y_burst)
              fut.add_done_callback(self._on_burst_done)

          def _drain_worker_results(self) -> None:
              while True:
                  try:
                      rows = self._result_queue.get_nowait()
                  except queue.Empty:
                      break
                  self._pending_rows.extend(rows)

          def _has_frame_len_tag(self, abs_offset: int) -> bool:
              for tag in self.get_tags_in_range(0, abs_offset, abs_offset + 1):
                  if tag.key == _TAG_FRAME_LEN:
                      return True
              return False

          def _finish_burst(self) -> None:
              y_burst = self._sym_buf.reshape(-1).astype(np.complex64, copy=False)
              self._sym_idx = 0
              self._submit_burst_async(y_burst)

          def _process_symbol(self, sym: np.ndarray, abs_offset: int) -> None:
              if self._sym_idx > 0 and self._has_frame_len_tag(abs_offset):
                  self._sym_idx = 0
              self._sym_buf[self._sym_idx, :] = np.asarray(sym, dtype=np.complex64).ravel()[
                  : self._fft_size
              ]
              self._sym_idx += 1
              if self._sym_idx >= self._payload_syms:
                  self._finish_burst()

          def work(self, input_items, output_items):
              self._drain_worker_results()

              inp = input_items[0]
              out = output_items[0]
              n_in = len(inp)
              produced = 0

              if n_in > 0:
                  if not self._ensure_waveform():
                      pass
                  else:
                      base = int(self.nitems_read(0))
                      for i in range(n_in):
                          self._process_symbol(inp[i], base + i)

              while produced < len(out) and self._pending_rows:
                  row, is_first, n_rows = self._pending_rows.popleft()
                  if is_first:
                      abs_out = self.nitems_written(0) + produced
                      self.add_item_tag(
                          0, abs_out, _TAG_PACKET_LEN, pmt.from_long(int(n_rows))
                      )
                  out[produced][:] = row
                  produced += 1

              return produced
    comment: GR sync + tag-driven payload + async LS/DD
    config_file: config_file
    device: device
    seed: '42'
  states: {}
- name: ofdm_burst_source
  id: epy_block
  parameters:
    _source_code: |
      """
      GNU Radio 嵌入式 Python 块：OFDM 突发源（SC 前导 + x_time.npy 时域重放）

      周期性输出 OFDM 时域突发，并在流上附加 UHD 所需的 stream tag：
        tx_sob  — 突发开始（Start Of Burst）
        tx_eob  — 突发结束（End Of Burst）

      Style 1 约定：下游 USRP Sink 的 len_tag_name 必须留空，由 tag 而非包长 tag 界定突发边界。
      不使用 tx_time 定时发射（RX 已用 SC 前导空口同步）。

      发射链：由 config_file 解析 source.cache_file（缓存目录）与 OFDM 几何，
      加载 x_time.npy（载荷，未缩放）→ 前缀拼接 Schmidl-Cox 时域前导 → 写出时乘
      当前 tx_amp 周期性重放。前导运行时生成，无需重写缓存。
      空口同步由 RX 对前导做相关完成；本块不再发 tx_schedule 消息。

      注意：__init__ 形参默认值须与 GRC 变量保持同步。
      """

      from __future__ import annotations

      import sys
      import time
      from pathlib import Path

      import numpy as np
      from gnuradio import gr

      from isac import PROJECT_ROOT
      from isac_imp.burst_pack import (
          TPP_DONT,
          add_style1_eob,
          add_style1_sob,
          load_burst_buffer,
          schedule_idle_delay_s,
      )
      from isac_imp.gr_setup import (
          resolve_gr_preamble_time,
          resolve_ofdm_fft_cp,
          resolve_ofdm_samp_rate,
          resolve_preamble_len,
          resolve_source_cache_file,
      )

      # ---------------------------------------------------------------------------
      # 模块常量
      # ---------------------------------------------------------------------------

      # 默认 TOML（相对 PROJECT_ROOT/config）；须与 GRC 默认值一致
      _DEFAULT_CONFIG = "simulation/sensing/sensing_monostatic.toml"
      _LOG_PREFIX = "[OFDM Burst Source]"  # stderr 日志前缀


      class blk(gr.basic_block):
          """
          Style 1 OFDM 突发源：SC 前导 + x_time.npy，周期性重放并打 SOB/EOB tag。

          工作流程：突发期内从缓存输出样本并打 tag；突发结束后进入 idle 静默期，
          静默期不产出样本（general_work 返回 0），到期再启动下一突发。
          """

          # -----------------------------------------------------------------------
          # 初始化
          # -----------------------------------------------------------------------

          def __init__(
              self,
              config_file=_DEFAULT_CONFIG,
              idle_ms=900.0,
              tx_amp=0.3,
              time_lead_s=0.3,
              startup_delay_s=0.2,
          ):
              """
              参数:
                  - config_file:      TOML 路径；从中解析 source.cache_file（目录）与 OFDM 几何
                  - idle_ms:          两次突发之间的纯静默间隔 (毫秒)，不含突发本身时长
                  - tx_amp:           输出幅度缩放（写出时相乘，可实时调节）
                  - time_lead_s:      保留兼容 GRC 形参，已不再使用
                  - startup_delay_s:  首突发启动前的初始等待 (秒)
              """
              gr.basic_block.__init__(
                  self,
                  name="OFDM Burst Source",
                  in_sig=[],
                  out_sig=[np.complex64],
              )
              self._config_file = str(config_file)
              self._cache_dir, self._samp_rate, self._fft_size, self._cp_len = (
                  self._resolve_from_config(self._config_file)
              )
              self._idle_ms = float(idle_ms)
              self._tx_amp = float(tx_amp)
              self._time_lead_s = float(time_lead_s)
              self._startup_delay_s = float(startup_delay_s)

              # 突发状态机：是否正在输出突发、当前写出位置、下一突发允许开始的 monotonic 时刻
              self._burst_active = False
              self._burst_idx = 0
              self._next_burst_at = time.monotonic() + self._startup_delay_s

              # 未缩放缓存波形（前导+载荷）、样本数、静默时长（秒）；写出时再乘 _tx_amp
              self._burst_buffer: np.ndarray | None = None
              self._burst_len = 0
              self._idle_s = max(0.0, self._idle_ms / 1000.0)

              # 源块无输入 tag；缓冲至少能装下一段突发，避免调度器切得过碎
              self.set_tag_propagation_policy(TPP_DONT)
              self.set_min_output_buffer(4096)

          # -----------------------------------------------------------------------
          # 配置解析与缓存加载
          # -----------------------------------------------------------------------

          @staticmethod
          def _resolve_from_config(config_file: str) -> tuple[str, float, int, int]:
              """解析 cache 目录、samp_rate、fft_size、cp（不建 System）。"""
              cache_dir = resolve_source_cache_file(config_file)
              samp_rate = float(resolve_ofdm_samp_rate(config_file))
              fft_size, cp_len = resolve_ofdm_fft_cp(config_file)
              return cache_dir, samp_rate, fft_size, cp_len

          def start(self):
              """流图启动时预热加载波形，避免首包冷启动导致 Sink underflow。"""
              self._ensure_burst()
              self._next_burst_at = time.monotonic() + self._startup_delay_s
              return True

          def _log(self, msg: str) -> None:
              """向 stderr 输出带前缀的日志（flush，便于实时观察）。"""
              print(f"{_LOG_PREFIX} {msg}", file=sys.stderr, flush=True)

          def _resolve_cache_dir(self) -> Path:
              """将缓存目录解析为绝对路径；相对路径相对 PROJECT_ROOT。"""
              path = Path(self._cache_dir)
              if not path.is_absolute():
                  path = PROJECT_ROOT / path
              return path

          def _invalidate_burst(self) -> None:
              """GRC 参数变更时清空本地缓存，下次 general_work 触发重建。"""
              self._burst_buffer = None

          def _ensure_burst(self) -> np.ndarray:
              """懒加载入口：缓存未命中时 np.load + 拼前导，返回突发缓冲。"""
              if self._burst_buffer is None:
                  self._load_burst()
              assert self._burst_buffer is not None
              return self._burst_buffer

          def _load_burst(self) -> None:
              """加载 x_time.npy，前缀 SC 前导，供写出时乘当前 tx_amp。"""
              path = self._resolve_cache_dir() / "x_time.npy"
              payload = load_burst_buffer(path, tx_amp=1.0)
              preamble = resolve_gr_preamble_time(self._config_file)
              burst_buffer = np.concatenate([preamble, payload]).astype(
                  np.complex64, copy=False
              )
              self._burst_buffer = burst_buffer
              self._burst_len = int(burst_buffer.size)
              self._idle_s = max(0.0, self._idle_ms / 1000.0)
              self.set_min_output_buffer(max(4096, self._burst_len))
              preamble_len = resolve_preamble_len(self._config_file)
              self._log(
                  f"load x_time.npy + GR SC preamble ok config={self._config_file!r} "
                  f"path={path} preamble_len={preamble_len} payload_len={payload.size} "
                  f"burst_len={self._burst_len} samp_rate={self._samp_rate}"
              )

          def _recompute_idle(self) -> None:
              """仅 idle_ms 变更时重算静默期，无需重建波形。"""
              self._idle_s = max(0.0, self._idle_ms / 1000.0)

          # -----------------------------------------------------------------------
          # GRC 可调属性
          # -----------------------------------------------------------------------

          @property
          def config_file(self):
              """TOML 配置路径（相对 config/ 或绝对路径）。"""
              return self._config_file

          @config_file.setter
          def config_file(self, value):
              """更新配置路径，重新解析缓存目录与 OFDM 几何，并清空突发缓存。"""
              self._config_file = str(value)
              self._cache_dir, self._samp_rate, self._fft_size, self._cp_len = (
                  self._resolve_from_config(self._config_file)
              )
              self._invalidate_burst()

          @property
          def cache_file(self):
              """只读：由 config_file 解析得到的缓存目录路径。"""
              return self._cache_dir

          @property
          def samp_rate(self):
              """只读：由 config_file 解析得到的 OFDM 采样率。"""
              return self._samp_rate

          @property
          def burst_len(self):
              """只读：当前突发缓冲的样本数（含前导；未加载前为 0）。"""
              return self._burst_len

          @property
          def idle_ms(self):
              """两次突发之间的纯静默间隔（毫秒）。"""
              return self._idle_ms

          @idle_ms.setter
          def idle_ms(self, value):
              """更新静默间隔并重算 _idle_s，无需重建波形。"""
              self._idle_ms = float(value)
              self._recompute_idle()

          @property
          def tx_amp(self):
              """输出幅度缩放系数（写出时相乘，可实时调节）。"""
              return self._tx_amp

          @tx_amp.setter
          def tx_amp(self, value):
              """仅更新幅度系数；不重载波形，下一写出块立即生效。"""
              self._tx_amp = float(value)

          @property
          def time_lead_s(self):
              """保留兼容 GRC；已不再打 tx_time。"""
              return self._time_lead_s

          @time_lead_s.setter
          def time_lead_s(self, value):
              """仅更新提前量；已发出的 tag 不受影响。"""
              self._time_lead_s = float(value)

          @property
          def startup_delay_s(self):
              """首突发启动前的初始等待（秒）。"""
              return self._startup_delay_s

          @startup_delay_s.setter
          def startup_delay_s(self, value):
              """仅更新参数；已调度的 _next_burst_at 需在 start() 中重设。"""
              self._startup_delay_s = float(value)

          # -----------------------------------------------------------------------
          # 调度与 general_work
          # -----------------------------------------------------------------------

          def forecast(self, noutput_items, ninputs):
              """无输入端口，不向调度器声明输入需求。"""
              del noutput_items, ninputs
              return []

          def _schedule_delay_s(self) -> float:
              """当前突发结束后到下一突发开始前的纯 idle 时长（秒）。"""
              return schedule_idle_delay_s(self._burst_len, self._samp_rate, self._idle_s)

          def general_work(self, input_items, output_items):
              """
              主工作函数：按块从缓存重放 OFDM 突发，在突发首尾附加 UHD tag。

              静默期内返回 0（不消耗输出缓冲）；突发可分多次 general_work 完成。
              返回值 n 表示本次写入输出端口的有效样本数。
              """
              del input_items
              burst_buffer = self._ensure_burst()
              out = output_items[0]

              # idle：未到下一突发时刻则不产出样本
              if not self._burst_active:
                  if time.monotonic() < self._next_burst_at:
                      return 0
                  # 启动新突发
                  self._burst_active = True
                  self._burst_idx = 0

              # 本轮可写样本数：受输出缓冲与突发剩余长度限制
              n_remain = self._burst_len - self._burst_idx
              n = min(len(out), n_remain)
              if n <= 0:
                  return 0

              # 从缓存拷贝一段并乘当前 tx_amp（实时可调）
              out[:n] = burst_buffer[self._burst_idx : self._burst_idx + n] * np.float32(
                  self._tx_amp
              )

              abs_out = self.nitems_written(0)
              if self._burst_idx == 0:
                  add_style1_sob(self, 0, abs_out)

              self._burst_idx += n
              # 突发末样本：打 EOB，进入 idle，调度下一突发时刻
              if self._burst_idx >= self._burst_len:
                  add_style1_eob(self, 0, abs_out + n - 1)
                  self._burst_active = False
                  self._next_burst_at = time.monotonic() + self._schedule_delay_s()

              return n
    comment: SC preamble + x_time.npy + SOB/EOB (no tx_time)
    config_file: config_file
    idle_ms: idle_ms
    startup_delay_s: startup_delay_s
    time_lead_s: time_lead_s
    tx_amp: tx_amp
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    comment: Burst-triggered spectrum (NORM, level=freq_trig_level)
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    label: RX Spectrum
    label1: RX
    name: RX Freq
    tr_level: freq_trig_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: gui_update_time_ms * 1e-3
    ymin: '-120'
  states: {state: disabled}
- name: qtgui_time_sink_tx
  id: qtgui_time_sink_x
  parameters:
    comment: TX digital clip check; flat top at 1.0 means saturation
    ctrlpanel: 'True'
    gui_hint: 2,0,1,3
    name: TX Time |IQ|
    size: int(ofdm_burst_samples)
    srate: samp_rate
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"tx_sob"'
    type: float
    update_time: gui_update_time_ms * 1e-3
    ylabel: '|IQ|'
    ymax: '1.0'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: 3,0,1,3
    name: RX Time |IQ|
    size: int(ofdm_burst_samples * 1.5)
    srate: samp_rate
    tr_level: time_mag_trig_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: gui_update_time_ms * 1e-3
    ylabel: '|IQ|'
    ymax: '0.5'
    ymin: '0'
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    clock_rate: '0'
    dev_addr: address
    dev_args: '""'
    gain0: TX_gain
    len_tag_name: ''
    samp_rate: samp_rate
    stream_args: num_send_frames=512,send_buff_size=25000000
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    center_freq0: freq
    clock_rate: '0'
    dev_addr: address
    dev_args: '""'
    gain0: RX_gain
    minoutbuf: '262144'
    samp_rate: samp_rate
    stream_args: num_recv_frames=512,recv_buff_size=25000000
    stream_chans: '[2]'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_tx, '0', qtgui_time_sink_tx, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_message_strobe_0, strobe, digital_header_payload_demux_0, header_data]
- [blocks_multiply_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_xx_0, '0', digital_header_payload_demux_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_header_payload_demux_0, '0', blocks_null_sink_hdr, '0']
- [digital_header_payload_demux_0, '1', ofdm_burst_sensing_rx, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0, '1']
- [ofdm_burst_sensing_rx, '0', dd_spectrum_plot_0, '0']
- [ofdm_burst_source, '0', blocks_complex_to_mag_tx, '0']
- [ofdm_burst_source, '0', blocks_tag_debug_0, '0']
- [ofdm_burst_source, '0', uhd_usrp_sink_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0_0, '0', digital_ofdm_sync_sc_cfb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
