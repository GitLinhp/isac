options:
  parameters:
    author: Lin Haopeng
    category: Custom
    copyright: Caict
    description: Style1 burst OFDM TX (Sionna) + GR OFDM RX sensing (X410 OTA)
    generate_options: qt_gui
    id: style1_ofdm_sensing
    output_language: python
    title: Style1 Burst OFDM Sensing (X410)
  states: {}

blocks:
- name: RX_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: rx_gain
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: TX_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: tx_gain
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: fft_len//4
  states: {}
- name: fft_len
  id: variable
  parameters:
    comment: Must exceed n_carriers so GR pilot tones (-n/2-2 …) stay in-band
    value: '2048'
  states: {}
- name: frame_len_tag
  id: variable
  parameters:
    comment: OFDM symbol length tag for CP block
    value: '"frame_len"'
  states: {}
- name: gui_update_period
  id: variable
  parameters:
    value: '0.10'
  states: {}
- name: hdr_ack_msg
  id: variable
  parameters:
    comment: HPD header_data; scheme A无包头, 告知超大payload
    value: pmt.dict_add(pmt.make_dict(), pmt.intern("frame_len"), pmt.from_long(hdr_payload_syms))
  states: {}
- name: hdr_payload_syms
  id: variable
  parameters:
    comment: HPD payload符号数, 应等于TX每标签帧数据符号数(ofdm_syms_per_tag)
    value: ofdm_syms_per_tag
  states: {}
- name: n_carriers
  id: variable
  parameters:
    value: '512'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (tuple(range(-n_carriers//2, 0)) + tuple(range(1, n_carriers//2+1)),)
  states: {}
- name: ofdm_syms_per_tag
  id: variable
  parameters:
    comment: OFDM symbols per allocator tagged frame
    value: '32'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, payload_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols, 1, 0.1)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: (tuple(range(-n_carriers//2-2, -n_carriers//2)) + tuple(range(n_carriers//2+1, n_carriers//2+3)),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((-1,1,-1,1),)
  states: {}
- name: rx_chain_min_buf
  id: variable
  parameters:
    comment: min output buffer for sync/HPD/multiply (one frame in time-domain samples)
    value: max(65536, int((2 + 1 + ofdm_syms_per_tag) * (fft_len + cp_len)))
  states: {}
- name: rx_vlen_buf
  id: variable
  parameters:
    comment: min output buffer for fft_len-vector RX blocks (one full frame)
    value: int((2 + 1 + ofdm_syms_per_tag) * fft_len * 16)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate derived from subcarrier_spacing * fft_len
    value: subcarrier_spacing * fft_len
  states: {}
- name: sionna_device
  id: variable
  parameters:
    value: '"cuda:0"'
  states: {}
- name: spectrum_decim
  id: variable
  parameters:
    comment: keep-1-in-N before spectrum GUI (reduces RX overflow)
    value: '4'
  states: {}
- name: subcarrier_spacing
  id: variable
  parameters:
    comment: OFDM subcarrier spacing (Hz); samp_rate = spacing * fft_len
    value: 15e3
  states: {}
- name: sync_word1
  id: variable
  parameters:
    comment: Schmidl-Cox preamble 1 (GR seed=42)
    value: list(digital.ofdm_txrx._make_sync_word1(fft_len, occupied_carriers, pilot_carriers))
  states: {}
- name: sync_word2
  id: variable
  parameters:
    comment: Schmidl-Cox preamble 2 (GR seed=42)
    value: list(digital.ofdm_txrx._make_sync_word2(fft_len, occupied_carriers, pilot_carriers))
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-3'
    stop: '200e-3'
    value: '50e-3'
  states: {}
- name: tx_repeat_period_ms
  id: variable_qtgui_range
  parameters:
    comment: UHD hardware burst repeat period (ms); SOB/EOB frame then RF idle until next period
    label: tx_repeat_ms
    start: '20'
    step: '1'
    stop: '2000'
    value: '1000'
  states: {}
- name: address
  id: parameter
  parameters:
    comment: RJ45 mgmt 1.100 + QSFP sfp0 10.2; host needs 192.168.10.1 on enp1s0f0np0
    label: UHD dev args
    type: str
    value: '"type=x4xx,mgmt_addr=192.168.1.100,addr=192.168.10.2"'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fft_len+cp_len
    type: complex
  states: {}
- name: blocks_keep_one_in_n_spectrum
  id: blocks_keep_one_in_n
  parameters:
    comment: decimate before spectrum GUI
    minoutbuf: '8192'
    n: spectrum_decim
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: HPD header_data; keep aligned with tx_repeat_ms
    msg: hdr_ack_msg
    period: int(tx_repeat_period_ms)
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    minoutbuf: rx_chain_min_buf
    type: complex
  states: {}
- name: blocks_null_sink_hdr
  id: blocks_null_sink
  parameters:
    comment: discard unused header port
    type: complex
    vlen: fft_len
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    comment: 2 sync + 1 placeholder header, then continuous payload
    guard_interval: cp_len
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: frame_len_tag
    minoutbuf: rx_chain_min_buf
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_ofdm_chanest_vcvc_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    comment: coarse sync + channel estimate from preamble
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: cp_len
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: frame_len_tag
    minoutbuf: int(rx_vlen_buf // 4)
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_0
  id: digital_ofdm_serializer_vcc
  parameters:
    fft_len: fft_len
    len_tag_key: frame_len_tag
    minoutbuf: int(n_carriers * ofdm_syms_per_tag * 16)
    occupied_carriers: occupied_carriers
  states: {}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    comment: Schmidl-Cox sync
    cp_len: cp_len
    fft_len: fft_len
    minoutbuf: rx_chain_min_buf
    threshold: '0.6'
  states: {}
- name: epy_fft_batch_hdr
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Torch batch FFT (GR fft_vxx replacement)

      Vector in/out (vlen = fft_len). Set the GRC variable fft_len, then run
      sync_ofdm_loopback_sionna_epy.py and grcc before starting the flowgraph.
      """

      from __future__ import annotations

      import sys

      import numpy as np
      import torch
      from gnuradio import gr

      _UHD_TEST_DIR = "/home/caict/Desktop/gunradio_test/uhd_test"
      if _UHD_TEST_DIR not in sys.path:
          sys.path.insert(0, _UHD_TEST_DIR)


      class blk(gr.sync_block):
          """Batch parallel FFT for HPD header/payload vector streams."""

          def __init__(self, fft_len=2048, device="cpu"):
              self._fft_len = int(fft_len)
              self._device = str(device)
              gr.sync_block.__init__(
                  self,
                  name="Torch Batch FFT",
                  in_sig=[(np.complex64, self._fft_len)],
                  out_sig=[(np.complex64, self._fft_len)],
              )
              torch.set_num_threads(1)

          @property
          def device(self) -> str:
              return self._device

          @device.setter
          def device(self, value: str) -> None:
              self._device = str(value)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n = min(len(inp), len(out))
              if n <= 0:
                  return 0

              batch = np.stack(
                  [np.asarray(inp[i], dtype=np.complex64) for i in range(n)], axis=0
              )
              x = torch.from_numpy(batch)
              dev = self._device
              if dev != "cpu":
                  x = x.to(dev)
              with torch.inference_mode():
                  freq = torch.fft.fftshift(torch.fft.fft(x, dim=-1), dim=-1)
              if dev != "cpu":
                  freq = freq.cpu()
              freq_np = freq.numpy().astype(np.complex64, copy=False)
              for i in range(n):
                  out[i][:] = freq_np[i]
              return n
    comment: Header/sync Torch batch FFT (replaces fft_vxx_hdr)
    device: sionna_device
    fft_len: fft_len
    minoutbuf: int(rx_vlen_buf // 4)
  states: {}
- name: epy_fft_batch_rx
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Torch batch FFT (GR fft_vxx replacement)

      Vector in/out (vlen = fft_len). Set the GRC variable fft_len, then run
      sync_ofdm_loopback_sionna_epy.py and grcc before starting the flowgraph.
      """

      from __future__ import annotations

      import sys

      import numpy as np
      import torch
      from gnuradio import gr

      _UHD_TEST_DIR = "/home/caict/Desktop/gunradio_test/uhd_test"
      if _UHD_TEST_DIR not in sys.path:
          sys.path.insert(0, _UHD_TEST_DIR)


      class blk(gr.sync_block):
          """Batch parallel FFT for HPD header/payload vector streams."""

          def __init__(self, fft_len=2048, device="cpu"):
              self._fft_len = int(fft_len)
              self._device = str(device)
              gr.sync_block.__init__(
                  self,
                  name="Torch Batch FFT",
                  in_sig=[(np.complex64, self._fft_len)],
                  out_sig=[(np.complex64, self._fft_len)],
              )
              torch.set_num_threads(1)

          @property
          def device(self) -> str:
              return self._device

          @device.setter
          def device(self, value: str) -> None:
              self._device = str(value)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n = min(len(inp), len(out))
              if n <= 0:
                  return 0

              batch = np.stack(
                  [np.asarray(inp[i], dtype=np.complex64) for i in range(n)], axis=0
              )
              x = torch.from_numpy(batch)
              dev = self._device
              if dev != "cpu":
                  x = x.to(dev)
              with torch.inference_mode():
                  freq = torch.fft.fftshift(torch.fft.fft(x, dim=-1), dim=-1)
              if dev != "cpu":
                  freq = freq.cpu()
              freq_np = freq.numpy().astype(np.complex64, copy=False)
              for i in range(n):
                  out[i][:] = freq_np[i]
              return n
    comment: Payload Torch batch FFT (replaces fft_vxx_rx)
    device: sionna_device
    fft_len: fft_len
    minoutbuf: int(rx_vlen_buf // 4)
  states: {}
- name: epy_sionna_phy_tx
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Style 1 Sionna PHY TX (GR-aligned, UHD hardware burst)

      Generate one OFDM frame at block construction, then reload that same waveform
      before each UHD burst (tx_sob / tx_time / tx_eob). Requires USRP Sink
      len_tag_name empty and sync=pc_clock with set_time_now().
      """

      from __future__ import annotations

      import sys
      import time

      import numpy as np
      import pmt
      import sionna as sn
      import torch
      from gnuradio import gr

      _UHD_TEST_DIR = "/home/caict/Desktop/gunradio_test/uhd_test"
      if _UHD_TEST_DIR not in sys.path:
          sys.path.insert(0, _UHD_TEST_DIR)

      from ofdm_loopback_phy_context import PhyContext

      _TAG_SOB = pmt.intern("tx_sob")
      _TAG_EOB = pmt.intern("tx_eob")
      _TAG_TIME = pmt.intern("tx_time")


      class blk(gr.basic_block):
          """Generate one frame at init; reload and replay on repeat_period_ms."""

          def __init__(
              self,
              device="cpu",
              tx_amp=0.05,
              repeat_period_ms=50.0,
              fft_len=2048,
              subcarrier_spacing=15e3,
              n_carriers=512,
              ofdm_syms_per_tag=32,
              time_lead_s=0.05,
          ):
              gr.basic_block.__init__(
                  self,
                  name="Style1 Sionna PHY TX",
                  in_sig=[],
                  out_sig=[np.complex64],
              )
              self._device = str(device)
              self._tx_amp = float(tx_amp)
              self._repeat_period_ms = float(repeat_period_ms)
              self._time_lead_s = float(time_lead_s)
              self._burst_active = False
              self._burst_idx = 0
              self._next_burst_time = 0.0
              self._frame: np.ndarray | None = None
              self._burst_buffer: np.ndarray | None = None
              self._phy = PhyContext.from_grc(
                  fft_len, subcarrier_spacing, n_carriers, ofdm_syms_per_tag
              )
              sn.phy.config.device = self._device
              torch.set_num_threads(1)
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self._initialize_frame()

          @property
          def phy(self) -> PhyContext:
              return self._phy

          @property
          def device(self):
              return self._device

          @property
          def tx_amp(self):
              return self._tx_amp

          @property
          def repeat_period_ms(self):
              return self._repeat_period_ms

          @property
          def time_lead_s(self):
              return self._time_lead_s

          @property
          def fft_len(self) -> int:
              return self._phy.fft_len

          @property
          def subcarrier_spacing(self) -> float:
              return self._phy.subcarrier_spacing

          @subcarrier_spacing.setter
          def subcarrier_spacing(self, value):
              self.reconfigure_phy(subcarrier_spacing=float(value))

          @property
          def n_carriers(self) -> int:
              return self._phy.n_carriers

          @n_carriers.setter
          def n_carriers(self, value):
              self.reconfigure_phy(n_carriers=int(value))

          @property
          def ofdm_syms_per_tag(self) -> int:
              return self._phy.ofdm_syms_data

          @ofdm_syms_per_tag.setter
          def ofdm_syms_per_tag(self, value):
              self.reconfigure_phy(ofdm_syms_per_tag=int(value))

          @tx_amp.setter
          def tx_amp(self, value):
              self._tx_amp = float(value)

          @repeat_period_ms.setter
          def repeat_period_ms(self, value):
              self._repeat_period_ms = float(value)

          @time_lead_s.setter
          def time_lead_s(self, value):
              self._time_lead_s = float(value)

          @device.setter
          def device(self, device):
              self._device = str(device)
              sn.phy.config.device = self._device
              self._rebuild_frame()

          def reconfigure_phy(
              self,
              fft_len=None,
              subcarrier_spacing=None,
              n_carriers=None,
              ofdm_syms_per_tag=None,
          ) -> None:
              self._phy = PhyContext.from_grc(
                  fft_len if fft_len is not None else self._phy.fft_len,
                  subcarrier_spacing
                  if subcarrier_spacing is not None
                  else self._phy.subcarrier_spacing,
                  n_carriers if n_carriers is not None else self._phy.n_carriers,
                  ofdm_syms_per_tag
                  if ofdm_syms_per_tag is not None
                  else self._phy.ofdm_syms_data,
              )
              self._rebuild_frame()

          def forecast(self, noutput_items, ninput_items):
              del noutput_items, ninput_items
              return []

          def _idle_gap_seconds(self) -> float:
              assert self._frame is not None
              frame_s = self._frame.size / self._phy.samp_rate
              period_s = max(self._repeat_period_ms / 1000.0, frame_s)
              return max(0.0, period_s - frame_s)

          def _tx_time_pmt(self):
              t = time.time() + self._time_lead_s
              sec = int(t)
              frac = t - sec
              return pmt.make_tuple(pmt.from_uint64(sec), pmt.from_double(frac))

          def _reset_burst_schedule(self, *, immediate: bool) -> None:
              self._burst_active = False
              self._burst_idx = 0
              self._next_burst_time = 0.0 if immediate else time.monotonic() + self._idle_gap_seconds()

          def _initialize_frame(self) -> None:
              """Generate random payload and OFDM waveform once at startup."""
              self._frame = self._build_frame_once()
              self._load_burst_buffer()
              self._reset_burst_schedule(immediate=True)
              self.set_min_output_buffer(int(self._frame.size) * 2)

          def _rebuild_frame(self) -> None:
              """Regenerate waveform only when PHY dimensions or device change."""
              self._initialize_frame()

          def _load_burst_buffer(self) -> None:
              """Load the cached frame before each burst (same data, scaled by tx_amp)."""
              assert self._frame is not None
              self._burst_buffer = (self._frame * self._tx_amp).astype(
                  np.complex64, copy=True
              )

          def _build_frame_once(self) -> np.ndarray:
              p = self._phy
              with torch.inference_mode():
                  binary_source = sn.phy.mapping.BinarySource(device=self._device)
                  mapper = sn.phy.mapping.Mapper("qam", 2, device=self._device)
                  modulator = sn.phy.ofdm.OFDMModulator(
                      cyclic_prefix_length=p.cp_len, device=self._device
                  )
                  bits = binary_source([p.bits_per_tag])
                  syms = mapper(bits).reshape(p.ofdm_syms_data, p.n_carriers)
                  grid = p.build_tx_freq_grid_torch(syms, device=self._device)
                  x = grid.unsqueeze(0).unsqueeze(0).unsqueeze(0)
                  y = modulator(x)
                  if self._device.startswith("cuda"):
                      torch.cuda.synchronize()
                  frame = y.squeeze()
                  if self._device != "cpu":
                      frame = frame.cpu()
                  return frame.detach().numpy().astype(np.complex64, copy=False)

          def general_work(self, input_items, output_items):
              del input_items
              out = output_items[0]
              assert self._frame is not None and self._burst_buffer is not None

              if not self._burst_active:
                  if time.monotonic() < self._next_burst_time:
                      return 0
                  self._load_burst_buffer()
                  self._burst_active = True
                  self._burst_idx = 0

              frame_len = self._frame.size
              n_remain = frame_len - self._burst_idx
              n = min(len(out), n_remain)
              if n <= 0:
                  return 0

              out[:n] = self._burst_buffer[self._burst_idx : self._burst_idx + n]
              abs_out = self.nitems_written(0)

              if self._burst_idx == 0:
                  self.add_item_tag(0, abs_out, _TAG_SOB, pmt.PMT_T)
                  self.add_item_tag(0, abs_out, _TAG_TIME, self._tx_time_pmt())

              self._burst_idx += n
              if self._burst_idx >= frame_len:
                  self.add_item_tag(0, abs_out + n - 1, _TAG_EOB, pmt.PMT_T)
                  self._burst_active = False
                  self._next_burst_time = time.monotonic() + self._idle_gap_seconds()

              return n
    comment: Style1 Sionna PHY TX (tx_sob/tx_time/tx_eob)
    device: sionna_device
    fft_len: fft_len
    minoutbuf: max(65536, int((2 + 1 + ofdm_syms_per_tag) * (fft_len + cp_len) * 2))
    n_carriers: n_carriers
    ofdm_syms_per_tag: ofdm_syms_per_tag
    repeat_period_ms: tx_repeat_period_ms
    subcarrier_spacing: subcarrier_spacing
    time_lead_s: '0.05'
    tx_amp: tx_amp
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Default Frequency
    short_id: f
    type: eng_float
    value: 6.0e9
  states: {}
- name: note_style1_ofdm
  id: note
  parameters:
    note: 'Style1 burst OFDM sensing: Sionna TX (tx_sob/tx_time/tx_eob) + GR OFDM RX. samp_rate=30.72 MS/s. OTA: start with low tx_amp/TX_gain. Use ISAC conda env (/home/caict/radioconda/envs/ISAC) for grcc and run. USRP sync=pc_clock. No GPU: set sionna_device to cpu. Burst interval: tx_repeat_period_ms (default 50 ms). Success: QPSK clusters in constellation sink.'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"OFDM RX symbols"'
    size: '16384'
    type: complex
    update_time: gui_update_period
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: fft_len
    label1: Rx Spectrum
    maxoutbuf: '8192'
    name: Rx Spectrum
    norm_window: 'True'
    showports: 'True'
    type: complex
    update_time: gui_update_period
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    clock_rate: '0'
    dev_addr: address
    dev_args: '""'
    gain0: TX_gain
    len_tag_name: ''
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    center_freq0: freq
    clock_rate: '0'
    dev_addr: address
    dev_args: '""'
    gain0: RX_gain
    minoutbuf: '262144'
    samp_rate: samp_rate
    stream_args: num_recv_frames=512,recv_buff_size=25000000
    stream_chans: '[2]'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_keep_one_in_n_spectrum, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_message_strobe_0, strobe, digital_header_payload_demux_0, header_data]
- [blocks_multiply_xx_0, '0', digital_header_payload_demux_0, '0']
- [digital_header_payload_demux_0, '0', epy_fft_batch_hdr, '0']
- [digital_header_payload_demux_0, '1', epy_fft_batch_rx, '0']
- [digital_ofdm_chanest_vcvc_0, '0', blocks_null_sink_hdr, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_ofdm_serializer_vcc_0, '0']
- [digital_ofdm_serializer_vcc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0, '1']
- [epy_fft_batch_hdr, '0', digital_ofdm_chanest_vcvc_0, '0']
- [epy_fft_batch_rx, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [epy_sionna_phy_tx, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', blocks_keep_one_in_n_spectrum, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_sync_sc_cfb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
