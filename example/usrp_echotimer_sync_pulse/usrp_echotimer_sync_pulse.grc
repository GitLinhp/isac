options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: usrp_echotimer_sync_pulse
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '6000000000'
  states: {}
- name: min_out_buf_val
  id: variable
  parameters:
    value: packet_len*2
  states: {}
- name: num_corr
  id: variable_qtgui_range
  parameters:
    label: Number of cross correlations
    start: '0'
    step: '1'
    stop: packet_len
    value: packet_len
  states: {}
- name: num_delay_samp
  id: variable_qtgui_range
  parameters:
    label: Number of delayed samples
    start: '0'
    step: '1'
    stop: packet_len
    value: '0'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: sum(wait_samp)+sum(send_samp)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '15360000'
  states: {}
- name: send_samp
  id: variable
  parameters:
    value: 100,400,300
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: uhd_dev_args
  id: variable
  parameters:
    comment: 'X410: RJ45 mgmt 1.100 + QSFP sfp0 10.2; host needs 192.168.10.1 on enp1s0f0np0'
    value: '"type=x4xx,mgmt_addr=192.168.1.100,addr=192.168.10.2"'
  states: {}
- name: wait_samp
  id: variable
  parameters:
    value: 100,100,100,100
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    comment: RX IQ diagnostic from echotimer
    name: RX echotimer
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    label1: ''
    label2: ''
    name: QT GUI Plot
    nconnections: '2'
    size: packet_len
    srate: samp_rate
    type: float
  states: {}
- name: radar_estimator_sync_pulse_c_0
  id: radar_estimator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    num_xcorr: int(num_corr)
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_signal_generator_sync_pulse_c_0
  id: radar_signal_generator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    minoutbuf: min_out_buf_val
    packet_len: packet_len
    pulse_amplitude: '0.5'
    pulse_len: send_samp
    pulse_pause: wait_samp
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    antenna_rx: '''RX1'''
    antenna_tx: '''TX/RX'''
    args_rx: uhd_dev_args
    args_tx: uhd_dev_args
    center_freq: center_freq
    channel_rx: '0'
    channel_tx: '0'
    clock_source_rx: '''internal'''
    gain_rx: rx_gain
    gain_tx: tx_gain
    minoutbuf: min_out_buf_val
    num_delay_samps: int(num_delay_samp)
    samp_rate: samp_rate
    time_source_rx: '''internal'''
    time_source_tx: '''internal'''
    timeout_rx: '0.2'
    timeout_tx: '0.2'
    wait_rx: wait_to_start
    wait_tx: wait_to_start
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '''J1'''
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: uhd_dev_args
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: '''packet_len'''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '''J1'''
    center_freq0: center_freq
    clock_rate: '0.0'
    clock_source0: mimo
    dev_addr: uhd_dev_args
    dev_args: '""'
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    time_source0: mimo
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0, '1']
- [radar_estimator_sync_pulse_c_0, Msg out, radar_print_results_0, Msg in]
- [radar_signal_generator_sync_pulse_c_0, '0', blocks_complex_to_mag_0, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', radar_estimator_sync_pulse_c_0, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', radar_usrp_echotimer_cc_0, '0']
- [radar_usrp_echotimer_cc_0, '0', blocks_complex_to_mag_1, '0']
- [radar_usrp_echotimer_cc_0, '0', blocks_tag_debug_0, '0']
- [radar_usrp_echotimer_cc_0, '0', radar_estimator_sync_pulse_c_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
